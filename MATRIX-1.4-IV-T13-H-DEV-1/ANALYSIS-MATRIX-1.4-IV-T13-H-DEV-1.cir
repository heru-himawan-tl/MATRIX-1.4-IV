.title MATRIX 1.4 IV T13 CLASS-H DEVELOPMENT RELEASE 1
.include "spice_models/model.lib"
R991 /POWER-AMP/PTCSL 0 100k
Rdummy2 /POWER-AMP/+24V /POWER-AMP/PTC_RL 660
Rdummy1 L_OUTPUT 0 4
V12 0 /POWER-AMP/-120V 120V DC
V41 /POWER-AMP/+24V 0 24V DC
V32 0 /POWER-AMP/-15V 15V DC
V31 /POWER-AMP/+15V 0 15V DC
V11 /POWER-AMP/+120V 0 120V DC
V14 0 /POWER-AMP/-60V 60V DC
V13 /POWER-AMP/+60V 0 60V DC
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
Q509 /POWER-AMP/PTC_RL Net-_Q509-Pad2_ 0 TIP41C
R525 Net-_Q508-Pad3_ Net-_Q509-Pad2_ 4.7k
R526 Net-_Q508-Pad3_ 0 4.7k
R524 /POWER-AMP/+24V Net-_C503-Pad1_ 100k
D516 Net-_C504-Pad2_ Net-_D516-Pad2_ 1N4148
D517 0 Net-_C504-Pad2_ 1N4148
R527 /POWER-AMP/PTC_RL /POWER-AMP/PTC_IND 10k
D518 /POWER-AMP/PTC_IND 0 LED_yellow
C504 /POWER-AMP/PTC_RL Net-_C504-Pad2_ 47uF
R710 /POWER-AMP/VSHSN Net-_D707-Pad2_ 10k
R702 /POWER-AMP/-60V /POWER-AMP/VSHTSN 10k
Q701 Net-_D704-Pad1_ /POWER-AMP/VSHTSN /POWER-AMP/-60V 2N5401
R703 Net-_D704-Pad1_ /POWER-AMP/-120V 15k
D515 /POWER-AMP/PTC_RL /POWER-AMP/+24V 1N4002
C503 Net-_C503-Pad1_ /POWER-AMP/+24V 0.1uF
Q508 /POWER-AMP/+24V Net-_C503-Pad1_ Net-_Q508-Pad3_ 2N5551
Q702 /POWER-AMP/VSHCN Net-_Q702-Pad2_ /POWER-AMP/-120V 2N5551
R704 Net-_D704-Pad1_ Net-_Q702-Pad2_ 15k
D705 /POWER-AMP/-120V Net-_D705-Pad2_ 1N4742
R706 Net-_D704-Pad2_ Net-_D705-Pad2_ 15k
S1 /POWER-AMP/PTCSL L_OUTPUT /POWER-AMP/+24V /POWER-AMP/PTC_RL sw1 ON
XQ7011 /POWER-AMP/VSHN /POWER-AMP/VSHGN /POWER-AMP/-120V IRF540
XQ7012 /POWER-AMP/VSHN /POWER-AMP/VSHGN /POWER-AMP/-120V IRF540
Q703 /POWER-AMP/VSHGN /POWER-AMP/VSHCN /POWER-AMP/-120V 2N5551
Q704 /POWER-AMP/-60V Net-_D705-Pad2_ /POWER-AMP/VSHGN 2N5551
R523 Net-_D511-Pad2_ Net-_D516-Pad2_ 100k
R522 Net-_D511-Pad2_ 0 100k
Q507 Net-_C503-Pad1_ Net-_D511-Pad2_ 0 2N5551
R4122 /POWER-AMP/+120V /POWER-AMP/VASDEP 820
R6011 /POWER-AMP/+120V Net-_D602-Pad1_ 33k
Q410 /POWER-AMP/+120V /POWER-AMP/VASP /POWER-AMP/DRVP1 MJE15032
Q404 /POWER-AMP/VASP Net-_C403-Pad1_ /POWER-AMP/VASDEP MJE350
R6012 /POWER-AMP/+120V Net-_D602-Pad1_ 33k
R4181 /POWER-AMP/DRVN1 /POWER-AMP/DRVP1 120
C405 /POWER-AMP/VASN /POWER-AMP/VASP 0.1uF
D601 V_OUT_INT /POWER-AMP/VSHSP 1N4742
R610 /POWER-AMP/VSHSP Net-_D607-Pad1_ 10k
Q412 /POWER-AMP/VSHP /POWER-AMP/DRVP1 /POWER-AMP/DRVP1 2SC5200
Q601 Net-_D604-Pad2_ /POWER-AMP/VSHTSP /POWER-AMP/+60V 2N5551
R602 /POWER-AMP/VSHTSP /POWER-AMP/+60V 10k
R603 /POWER-AMP/+120V Net-_D604-Pad2_ 15k
R608 Net-_Q605-Pad2_ /POWER-AMP/+60V 15k
Q605 Net-_Q605-Pad1_ Net-_Q605-Pad2_ /POWER-AMP/VSHP 2N5401
R607 /POWER-AMP/VSHP /POWER-AMP/VSHTSP 15k
D608 /POWER-AMP/VSHTSP Net-_D608-Pad2_ 1N4007
D603 Net-_D602-Pad1_ /POWER-AMP/VSHTSP 1N4007
D607 Net-_D607-Pad1_ /POWER-AMP/+60V 1N4007
Q606 Net-_D608-Pad2_ Net-_D607-Pad1_ /POWER-AMP/VSHSP 2N5551
D602 Net-_D602-Pad1_ /POWER-AMP/VSHSP 1N4007
C601 Net-_D608-Pad2_ Net-_D607-Pad1_ 470pF
R609 Net-_D607-Pad1_ Net-_Q605-Pad1_ 15k
D701 /POWER-AMP/VSHSN V_OUT_INT 1N4742
R419 V_OUT_INT /POWER-AMP/DRVP1 5.6
R420 /POWER-AMP/DRVN2 V_OUT_INT 5.6
Q413 /POWER-AMP/VSHN /POWER-AMP/DRVN1 /POWER-AMP/DRVN2 2SA1943
Q4141 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q4141-Pad3_ 2SC5200
Q4151 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q4151-Pad3_ 2SA1943
R4211 Net-_Q4141-Pad3_ V_OUT_INT 0.56
R4221 V_OUT_INT Net-_Q4151-Pad3_ 0.56
D507 /POWER-AMP/PTCSC_O /POWER-AMP/+15V 1N4007
R508 /POWER-AMP/+120V Net-_Q503-Pad2_ 1.2k
D506 Net-_D506-Pad1_ Net-_D506-Pad2_ 1N4007
R503 /POWER-AMP/PTCSL Net-_D503-Pad2_ 10k
D503 Net-_D503-Pad1_ Net-_D503-Pad2_ 1N4732
R505 /POWER-AMP/PTCSC_O Net-_D506-Pad1_ 100k
D509 Net-_C502-Pad1_ /POWER-AMP/+15V 1N4007
R514 V_OUT_INT Net-_C502-Pad1_ 100k
C502 Net-_C502-Pad1_ 0 220uF
D510 /POWER-AMP/-15V Net-_C502-Pad1_ 1N4007
D505 Net-_D505-Pad1_ Net-_D505-Pad2_ 1N4007
D502 Net-_D502-Pad1_ Net-_D501-Pad2_ 1N4007
R502 Net-_D501-Pad1_ /POWER-AMP/PTCSL 10k
R504 Net-_D505-Pad2_ /POWER-AMP/PTCSC_O 100k
D501 Net-_D501-Pad1_ Net-_D501-Pad2_ 1N4732
XU501 Net-_R513-Pad1_ Net-_R513-Pad1_ /POWER-AMP/PTCSC_O /POWER-AMP/-15V Net-_C502-Pad1_ Net-_R516-Pad2_ /POWER-AMP/PTCOC_SO /POWER-AMP/+15V RC4558_IMPL
R4082 Net-_Q403-Pad3_ /POWER-AMP/-120V 47k
D401 /POWER-AMP/-120V Net-_D401-Pad2_ 1N4732
R4081 Net-_Q403-Pad3_ /POWER-AMP/-120V 470
R501 P_OUTPUT /POWER-AMP/PTCSL 0.1
Q501 Net-_D505-Pad1_ Net-_D502-Pad1_ P_OUTPUT 2N5401
R4074 0 Net-_D401-Pad2_ 56k
R4073 0 Net-_D401-Pad2_ 56k
Q403 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q403-Pad3_ MJE340
Q407 Net-_C406-Pad1_ Net-_C406-Pad1_ Net-_Q407-Pad3_ MJE340
R4112 Net-_Q407-Pad3_ /POWER-AMP/-120V 820
R4111 Net-_Q407-Pad3_ /POWER-AMP/-120V 150
C406 Net-_C406-Pad1_ /POWER-AMP/VASN 47pF
R4172 Net-_Q409-Pad3_ /POWER-AMP/-120V 820
Q409 /POWER-AMP/VASN Net-_C406-Pad1_ Net-_Q409-Pad3_ MJE340
R4171 Net-_Q409-Pad3_ /POWER-AMP/-120V 150
R4213 Net-_Q4143-Pad3_ V_OUT_INT 0.56
R4214 Net-_Q4144-Pad3_ V_OUT_INT 0.56
R4212 Net-_Q4142-Pad3_ V_OUT_INT 0.56
Q4143 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q4143-Pad3_ 2SC5200
Q4144 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q4144-Pad3_ 2SC5200
Q4146 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q4146-Pad3_ 2SC5200
Q4142 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q4142-Pad3_ 2SC5200
Q4145 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q4145-Pad3_ 2SC5200
Q41510 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q41510-Pad3_ 2SA1943
Q4159 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q4159-Pad3_ 2SA1943
Q4155 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q4155-Pad3_ 2SA1943
Q4156 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q4156-Pad3_ 2SA1943
Q4158 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q4158-Pad3_ 2SA1943
Q4157 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q4157-Pad3_ 2SA1943
Q4147 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q4147-Pad3_ 2SC5200
Q4148 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q4148-Pad3_ 2SC5200
Q41410 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q41410-Pad3_ 2SC5200
Q4154 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q4154-Pad3_ 2SA1943
Q4153 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q4153-Pad3_ 2SA1943
Q4152 /POWER-AMP/VSHN /POWER-AMP/DRVN2 Net-_Q4152-Pad3_ 2SA1943
R4223 V_OUT_INT Net-_Q4153-Pad3_ 0.56
R4222 V_OUT_INT Net-_Q4152-Pad3_ 0.56
R4219 Net-_Q4149-Pad3_ V_OUT_INT 0.56
R4218 Net-_Q4148-Pad3_ V_OUT_INT 0.56
R4229 V_OUT_INT Net-_Q4159-Pad3_ 0.56
R4228 V_OUT_INT Net-_Q4158-Pad3_ 0.56
Q4149 /POWER-AMP/VSHP /POWER-AMP/DRVP1 Net-_Q4149-Pad3_ 2SC5200
R4227 V_OUT_INT Net-_Q4157-Pad3_ 0.56
R4224 V_OUT_INT Net-_Q4154-Pad3_ 0.56
R4225 V_OUT_INT Net-_Q4155-Pad3_ 0.56
R4226 V_OUT_INT Net-_Q4156-Pad3_ 0.56
R4216 Net-_Q4146-Pad3_ V_OUT_INT 0.56
R4217 Net-_Q4147-Pad3_ V_OUT_INT 0.56
R4215 Net-_Q4145-Pad3_ V_OUT_INT 0.56
R4101 /POWER-AMP/+120V Net-_Q405-Pad3_ 150
R409 /POWER-AMP/+120V Net-_C404-Pad1_ 1.2k
Q405 /POWER-AMP/VASDIFF Net-_C404-Pad1_ Net-_Q405-Pad3_ MJE350
R4121 /POWER-AMP/+120V /POWER-AMP/VASDEP 150
C403 Net-_C403-Pad1_ /POWER-AMP/VASP 47pF
R4102 /POWER-AMP/+120V Net-_Q405-Pad3_ 820
Q402 Net-_C404-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ 2N5551
Q401 Net-_C403-Pad1_ Net-_Q401-Pad2_ Net-_Q401-Pad3_ 2N5551
R4031 V_OUT_INT Net-_Q402-Pad2_ 15k
R4032 V_OUT_INT Net-_Q402-Pad2_ 270k
C402 Net-_C402-Pad1_ 0 220uF
C404 Net-_C404-Pad1_ /POWER-AMP/VASDIFF 47pF
R404 Net-_C402-Pad1_ Net-_Q402-Pad2_ 180
R416 /POWER-AMP/VASP Net-_R415-Pad1_ 2.2k
RT402 /POWER-AMP/VASP Net-_R415-Pad1_ 5k
R415 Net-_R415-Pad1_ Net-_Q408-Pad2_ 390
R4021 Net-_Q401-Pad2_ 0 15k
R4022 Net-_Q401-Pad2_ 0 270k
R4071 0 Net-_D401-Pad2_ 56k
R4072 0 Net-_D401-Pad2_ 56k
Q406 Net-_C406-Pad1_ 0 /POWER-AMP/VASDIFF MJE350
R413 Net-_Q408-Pad2_ /POWER-AMP/VASN 1.2k
Q408 /POWER-AMP/VASN Net-_Q408-Pad2_ /POWER-AMP/VASP MJE350
R414 Net-_Q408-Pad2_ /POWER-AMP/VASP 390
C401 MAIN_IN Net-_C401-Pad2_ 10uF
R401 Net-_C401-Pad2_ Net-_Q401-Pad2_ 180
R4052 /POWER-AMP/+120V Net-_C403-Pad1_ 27k
R4051 /POWER-AMP/+120V Net-_C403-Pad1_ 1.5k
R406 Net-_R406-Pad1_ Net-_C403-Pad1_ 4.7k
RT401 /POWER-AMP/+120V Net-_R406-Pad1_ 2.5k
R516 0 Net-_R516-Pad2_ 10k
R517 Net-_R516-Pad2_ /POWER-AMP/PTCOC_SO 100k
R515 Net-_C502-Pad1_ 0 100k
R511 Net-_Q503-Pad1_ /POWER-AMP/PTCSC_O 10k
R512 Net-_Q504-Pad1_ /POWER-AMP/PTCSC_O 10k
C501 /POWER-AMP/PTCSC_O 0 0.1uF
R518 /POWER-AMP/PTCOC_SO Net-_D513-Pad1_ 10k
R506 /POWER-AMP/PTCSC_O 0 10k
D703 /POWER-AMP/VSHTSN Net-_D702-Pad2_ 1N4007
Q706 Net-_D708-Pad1_ Net-_D707-Pad2_ /POWER-AMP/VSHSN 2N5401
D702 /POWER-AMP/VSHSN Net-_D702-Pad2_ 1N4007
R7011 /POWER-AMP/-120V Net-_D702-Pad2_ 33k
R7012 /POWER-AMP/-120V Net-_D702-Pad2_ 33k
Q411 /POWER-AMP/-120V /POWER-AMP/VASN /POWER-AMP/DRVN1 MJE15033
D708 Net-_D708-Pad1_ /POWER-AMP/VSHTSN 1N4007
C701 Net-_D708-Pad1_ Net-_D707-Pad2_ 470pF
Q503 Net-_Q503-Pad1_ Net-_Q503-Pad2_ /POWER-AMP/+120V 2N5401
Q504 Net-_Q504-Pad1_ Net-_Q504-Pad2_ /POWER-AMP/-120V 2N5551
D508 /POWER-AMP/-15V /POWER-AMP/PTCSC_O 1N4007
R509 0 Net-_Q504-Pad2_ 330k
R510 /POWER-AMP/-120V Net-_Q504-Pad2_ 1.2k
R507 Net-_Q503-Pad2_ 0 330k
Q502 Net-_D506-Pad2_ Net-_D504-Pad2_ P_OUTPUT 2N5551
D504 Net-_D503-Pad1_ Net-_D504-Pad2_ 1N4007
R513 Net-_R513-Pad1_ Net-_D511-Pad1_ 10k
Q505 Net-_Q505-Pad1_ 0 Net-_D512-Pad1_ 2N5551
D514 Net-_D512-Pad1_ Net-_D513-Pad1_ 1N4148
R521 Net-_Q506-Pad1_ Net-_D511-Pad2_ 10k
D512 Net-_D512-Pad1_ Net-_D511-Pad1_ 1N4148
D513 Net-_D513-Pad1_ Net-_D511-Pad2_ 1N4148
D511 Net-_D511-Pad1_ Net-_D511-Pad2_ 1N4148
R519 Net-_Q506-Pad2_ Net-_Q505-Pad1_ 10k
R520 /POWER-AMP/+15V Net-_Q506-Pad2_ 10k
Q506 Net-_Q506-Pad1_ Net-_Q506-Pad2_ /POWER-AMP/+15V 2N5401
R707 /POWER-AMP/VSHN /POWER-AMP/VSHTSN 15k
D707 /POWER-AMP/-60V Net-_D707-Pad2_ 1N4007
R708 /POWER-AMP/-60V Net-_Q705-Pad2_ 15k
Q705 Net-_Q705-Pad1_ Net-_Q705-Pad2_ /POWER-AMP/VSHN 2N5551
R709 Net-_D707-Pad2_ Net-_Q705-Pad1_ 15k
D606 /POWER-AMP/+60V /POWER-AMP/VSHP MURF1560
Q604 /POWER-AMP/+60V Net-_D605-Pad1_ /POWER-AMP/VSHGP 2N5401
D605 Net-_D605-Pad1_ /POWER-AMP/+120V 1N4742
Q603 /POWER-AMP/VSHGP /POWER-AMP/VSHCP /POWER-AMP/+120V 2N5401
R42210 V_OUT_INT Net-_Q41510-Pad3_ 0.56
R42110 Net-_Q41410-Pad3_ V_OUT_INT 0.56
Q707 Net-_Q707-Pad1_ Net-_Q707-Pad2_ /POWER-AMP/VSHN BF422
R711 /POWER-AMP/-60V Net-_Q707-Pad2_ 10k
R712 Net-_Q707-Pad1_ /POWER-AMP/VSHP 10k
D412 /POWER-AMP/-120V V_OUT_INT MURF1560
C407 0 Net-_C407-Pad2_ 0.1uF
R423 V_OUT_INT Net-_C407-Pad2_ 10
D706 /POWER-AMP/VSHN /POWER-AMP/-60V MURF1560
R611 /POWER-AMP/+60V Net-_Q607-Pad2_ 10k
XQ6011 /POWER-AMP/VSHP /POWER-AMP/VSHGP /POWER-AMP/+120V IRF9540
R612 /POWER-AMP/VSHN Net-_Q607-Pad1_ 10k
Q607 Net-_Q607-Pad1_ Net-_Q607-Pad2_ /POWER-AMP/VSHP BF423
D411 V_OUT_INT /POWER-AMP/+120V MURF1560
XQ6012 /POWER-AMP/VSHP /POWER-AMP/VSHGP /POWER-AMP/+120V IRF9540
L401 V_OUT_INT P_OUTPUT 1uH
R606 Net-_D604-Pad1_ Net-_D605-Pad1_ 15k
R604 Net-_Q602-Pad2_ Net-_D604-Pad2_ 15k
Q602 /POWER-AMP/VSHCP Net-_Q602-Pad2_ /POWER-AMP/+120V 2N5401
R6051 /POWER-AMP/VSHCP /POWER-AMP/+60V 33k
R6052 /POWER-AMP/VSHCP /POWER-AMP/+60V 33k
D604 Net-_D604-Pad1_ Net-_D604-Pad2_ 1N4148
D704 Net-_D704-Pad1_ Net-_D704-Pad2_ 1N4148
R7051 /POWER-AMP/VSHCN /POWER-AMP/-60V 15k
R7052 /POWER-AMP/VSHCN /POWER-AMP/-60V 15k
.end
