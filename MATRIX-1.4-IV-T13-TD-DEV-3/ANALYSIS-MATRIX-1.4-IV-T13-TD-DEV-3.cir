.title MATRIX 1.4 IV T13 1400W RMS TD-CLASS - DEVELOPMENT RELEASE 3
.include "spice_models/model.lib"
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
V11 +120V 0 DC 120V
V12 0 -120V DC 120V
R901 VPOUT 0 4
R712 Net-_Q709-Pad2_ VSGSPN 2.7k
R713 -120V Net-_Q709-Pad2_ 15k
R714 Net-_Q709-Pad2_ Net-_D707-Pad1_ 2.7k
R717 Net-_Q711-Pad3_ -120V 27k
XQ7011 VSFN VSGN -120V IRF640
XQ7012 VSFN VSGN -120V IRF640
C706 -120V VSAVN 1uF
Q712 VSGN Net-_Q711-Pad3_ -120V 2N5551
R716 Net-_D707-Pad2_ VSGN 4.7
Q711 VSGN VSTAN2 Net-_Q711-Pad3_ 2N5551
D707 Net-_D707-Pad1_ Net-_D707-Pad2_ BAV21
R719 VSFN Net-_C705-Pad2_ 680
C705 VSAVN Net-_C705-Pad2_ 2200pF
Q710 Net-_D707-Pad2_ Net-_Q709-Pad1_ VSGSPN 2N5401
L701 VSAVN VSFN 10uH
D709 VSFN 0 MURF1560
R420 VMOUT Net-_C406-Pad2_ 10
C406 0 Net-_C406-Pad2_ 0.1uF
L401 VPOUT VMOUT 1uH
Q601 0 Net-_C601-Pad2_ Net-_D603-Pad1_ 2N5401
D603 Net-_D603-Pad1_ Net-_C602-Pad1_ 1N4734
R602 Net-_C601-Pad1_ Net-_C602-Pad1_ 120k
C601 Net-_C601-Pad1_ Net-_C601-Pad2_ 4.7uF
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
R601 +120V Net-_D601-Pad1_ 12k
C602 Net-_C602-Pad1_ +120V 33pF
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 390
RT401 VASP Net-_R412-Pad1_ 5k
R4031 VMOUT Net-_Q402-Pad2_ 15k
R413 VASP Net-_R412-Pad1_ 2.2k
R404 Net-_Q402-Pad2_ Net-_C403-Pad1_ 180
C403 Net-_C403-Pad1_ 0 220uF
Q403 Net-_Q402-Pad1_ Net-_Q402-Pad1_ Net-_Q403-Pad3_ MPSA92
C404 Net-_C404-Pad1_ VASP 220pF
R4051 +120V Net-_Q403-Pad3_ 56
R4052 +120V Net-_Q403-Pad3_ 470
Q406 VASP Net-_C404-Pad1_ Net-_Q406-Pad3_ MJE350
R4091 +120V Net-_Q406-Pad3_ 150
R4092 +120V Net-_Q406-Pad3_ 820
R4032 VMOUT Net-_Q402-Pad2_ 270k
D602 VMOUT Net-_C601-Pad2_ 1N4007
R603 Net-_C601-Pad2_ 0 120k
Q411 VSAVP DRVP1 DRVP2 2SC5200
Q409 +120V VASP DRVP1 MJE15032
R4062 +120V Net-_Q404-Pad3_ 470
Q404 Net-_C404-Pad1_ Net-_Q402-Pad1_ Net-_Q404-Pad3_ MPSA92
C408 +120V 0 10uF
C407 0 +120V 0.1uF
R4061 +120V Net-_Q404-Pad3_ 56
C402 0 Net-_C402-Pad2_ 220pF
Q401 Net-_C404-Pad1_ Net-_C402-Pad2_ Net-_Q401-Pad3_ MPSA42
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ MPSA42
R401 Net-_C402-Pad2_ Net-_C401-Pad2_ 180
R4022 Net-_C402-Pad2_ 0 270k
R4021 Net-_C402-Pad2_ 0 15k
C401 MAIN_IN Net-_C401-Pad2_ 10uF
D604 +120V Net-_D604-Pad2_ MURF1560
Q602 +120V Net-_C602-Pad1_ Net-_Q602-Pad3_ MJE340
D605 Net-_D604-Pad2_ VSTCP MURF1560
R604 Net-_Q602-Pad3_ VSAVP 1.5k
Q603 +120V Net-_Q602-Pad3_ Net-_Q603-Pad3_ MJE15032
R605 Net-_Q603-Pad3_ VSAVP 56
C606 VSAVP +120V 1uF
L601 VSAVP VSFP 10uH
XQ6012 VSFP VSGP +120V IRF9640
XQ6011 VSFP VSGP +120V IRF9640
C605 VSAVP Net-_C605-Pad2_ 2200pF
R619 VSFP Net-_C605-Pad2_ 680
Q609 Net-_Q609-Pad1_ Net-_Q609-Pad2_ Net-_D606-Pad2_ 2N5401
R611 +120V Net-_D606-Pad1_ 2.7k
D606 Net-_D606-Pad1_ Net-_D606-Pad2_ BAV21
Q605 Net-_Q605-Pad1_ Net-_Q605-Pad2_ +120V 2N5401
Q608 VSGSPP VSTAP1 Net-_D606-Pad2_ 2N5401
Q606 +120V Net-_Q605-Pad1_ VSTAP1 2N5551
Q607 +120V Net-_Q605-Pad1_ VSTAP2 2N5551
R607 VSTCP Net-_Q605-Pad2_ 150
D608 Net-_C603-Pad2_ +120V 1N4749
R606 +120V VSTCP 1
C603 +120V Net-_C603-Pad2_ 4.7uF
C604 +120V VSGSPP 47uF
Q4136 VSAVP DRVP2 Net-_Q4136-Pad3_ 2SC5200
Q4135 VSAVP DRVP2 Net-_Q4135-Pad3_ 2SC5200
Q4134 VSAVP DRVP2 Net-_Q4134-Pad3_ 2SC5200
R608 Net-_Q605-Pad1_ VSGSPP 2.7k
D402 VMOUT VSAVP MURF1560
R610 VSTAP2 VSGSPP 2.7k
Q614 VSGSPP Net-_Q613-Pad1_ 0 MJE340
Q613 Net-_Q613-Pad1_ Net-_C603-Pad2_ VSGSPP 2N5401
Q604 VSTCP Net-_Q603-Pad3_ VSAVP 2SC5200
Q4131 VSAVP DRVP2 Net-_Q4131-Pad3_ 2SC5200
R618 Net-_C603-Pad2_ 0 100k
Q4133 VSAVP DRVP2 Net-_Q4133-Pad3_ 2SC5200
Q4132 VSAVP DRVP2 Net-_Q4132-Pad3_ 2SC5200
D609 0 VSFP MURF1560
R614 Net-_Q609-Pad2_ Net-_D607-Pad2_ 2.7k
R616 VSGP Net-_Q610-Pad1_ 4.7
R613 +120V Net-_Q609-Pad2_ 15k
Q610 Net-_Q610-Pad1_ Net-_Q609-Pad1_ VSGSPP 2N5551
Q612 VSGP Net-_Q611-Pad3_ +120V 2N5401
R617 +120V Net-_Q611-Pad3_ 27k
D607 Net-_Q610-Pad1_ Net-_D607-Pad2_ BAV21
Q611 VSGP VSTAP2 Net-_Q611-Pad3_ 2N5401
R615 Net-_Q609-Pad1_ VSGSPP 2.7k
R612 Net-_Q609-Pad2_ VSGSPP 2.7k
R609 VSTAP1 VSGSPP 2.7k
R4071 0 Net-_D401-Pad2_ 56k
R4073 0 Net-_D401-Pad2_ 56k
R4072 0 Net-_D401-Pad2_ 56k
R410 Net-_Q407-Pad2_ VASN 1.2k
R4081 Net-_Q405-Pad3_ -120V 470
R4074 0 Net-_D401-Pad2_ 56k
C409 -120V 0 0.1uF
C410 0 -120V 10uF
R4082 Net-_Q405-Pad3_ -120V 47k
Q405 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q405-Pad3_ MJE340
R701 Net-_D701-Pad2_ -120V 12k
D704 Net-_D704-Pad1_ -120V MURF1560
C702 -120V Net-_C702-Pad2_ 33pF
D705 VSTCN Net-_D704-Pad1_ MURF1560
Q702 -120V Net-_C702-Pad2_ Net-_Q702-Pad3_ MJE350
Q703 -120V Net-_Q702-Pad3_ Net-_Q703-Pad3_ MJE15033
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R702 Net-_C701-Pad2_ Net-_C702-Pad2_ 120k
R4142 Net-_Q408-Pad3_ -120V 47k
R4141 Net-_Q408-Pad3_ -120V 470
Q408 VASN Net-_D401-Pad2_ Net-_Q408-Pad3_ MJE340
D401 -120V Net-_D401-Pad2_ 1N4732
Q704 VSTCN Net-_Q703-Pad3_ VSAVN 2SA1943
R705 VSAVN Net-_Q703-Pad3_ 56
Q412 VSAVN DRVN1 DRVN2 2SA1943
R417 DRVN2 VMOUT 5.6
R416 VMOUT DRVP2 5.6
R704 VSAVN Net-_Q702-Pad3_ 1.5k
R4151 DRVN1 DRVP1 120
Q701 0 Net-_C701-Pad1_ Net-_D703-Pad2_ 2N5551
D703 Net-_C702-Pad2_ Net-_D703-Pad2_ 1N4734
C701 Net-_C701-Pad1_ Net-_C701-Pad2_ 4.7uF
R703 0 Net-_C701-Pad1_ 120k
Q410 -120V VASN DRVN1 MJE15033
C405 VASN VASP 0.1uF
Q407 VASN Net-_Q407-Pad2_ VASP MJE350
R411 Net-_Q407-Pad2_ VASP 390
D702 Net-_C701-Pad1_ VMOUT 1N4007
Q4145 VSAVN DRVN2 Net-_Q4145-Pad3_ 2SA1943
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
Q4144 VSAVN DRVN2 Net-_Q4144-Pad3_ 2SA1943
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
R4193 VMOUT Net-_Q4143-Pad3_ 0.33
R718 0 Net-_C703-Pad1_ 100k
R708 Net-_Q705-Pad1_ VSGSPN 2.7k
Q714 VSGSPN Net-_Q713-Pad1_ 0 MJE350
Q713 Net-_Q713-Pad1_ Net-_C703-Pad1_ VSGSPN 2N5551
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
Q4142 VSAVN DRVN2 Net-_Q4142-Pad3_ 2SA1943
Q4141 VSAVN DRVN2 Net-_Q4141-Pad3_ 2SA1943
Q4143 VSAVN DRVN2 Net-_Q4143-Pad3_ 2SA1943
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
R707 VSTCN Net-_Q705-Pad2_ 150
R706 VSTCN -120V 1
C703 Net-_C703-Pad1_ -120V 4.7uF
D708 -120V Net-_C703-Pad1_ 1N4749
C704 VSGSPN -120V 47uF
Q705 Net-_Q705-Pad1_ Net-_Q705-Pad2_ -120V 2N5551
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
Q4146 VSAVN DRVN2 Net-_Q4146-Pad3_ 2SA1943
D403 VSAVN VMOUT MURF1560
Q706 -120V Net-_Q705-Pad1_ VSTAN1 2N5401
R709 VSTAN1 VSGSPN 2.7k
Q707 -120V Net-_Q705-Pad1_ VSTAN2 2N5401
R711 -120V Net-_D706-Pad2_ 2.7k
R715 Net-_Q709-Pad1_ VSGSPN 2.7k
Q709 Net-_Q709-Pad1_ Net-_Q709-Pad2_ Net-_D706-Pad1_ 2N5551
D706 Net-_D706-Pad1_ Net-_D706-Pad2_ BAV21
R710 VSTAN2 VSGSPN 2.7k
Q708 VSGSPN VSTAN1 Net-_D706-Pad1_ 2N5551
.end
