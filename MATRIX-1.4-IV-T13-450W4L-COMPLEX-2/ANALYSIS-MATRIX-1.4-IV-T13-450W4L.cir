.title MATRIX 1.4 IV T13 450W4L
.include "spice_models/model.lib"
Rdummy1 L_OUTPUT 0 4
Rdummy2 /POWER-AMP/PTC_RL /POWER-AMP/+24V 660
V1 /POWER-AMP/+75V 0 75V DC
V2 0 /POWER-AMP/-75V 75V DC
V7 /POWER-AMP/+24V 0 24V DC
V3 /POWER-AMP/+15V 0 15V DC
V4 0 /POWER-AMP/-15V 15V DC
V5 +BAL_IN 0 dc 0 ac 1.41 sin(0 5 100 0 0)
V6 0 -BAL_IN dc 0 ac 1.41 sin(0 5 100 0 0)
Rvol1 VOL_SRC VOL_CTL 1
R401 LIMITER_OUT Net-_C401-Pad1_ 330
XU202 /POWER-AMP/vlmao Net-_D208-Pad1_ Net-_D207-Pad1_ /POWER-AMP/-15V /POWER-AMP/vslimit LIMITER_OUT LIMITER_OUT /POWER-AMP/+15V RC4558_IMPL
R201 Net-_R201-Pad1_ /POWER-AMP/vslimit 3.3k
R210 /POWER-AMP/+15V Net-_R210-Pad2_ 2.7k
XU201 Net-_R210-Pad2_ LIMITER_IND_SRC 0 /POWER-AMP/vslimit NSL32SR3
RT401 /POWER-AMP/+75V Net-_R406-Pad1_ 2.7k
R406 Net-_R406-Pad1_ Net-_Q401-Pad1_ 4.7k
XU301 Net-_R302-Pad2_ Net-_R301-Pad2_ LIMITER_OUT /POWER-AMP/-15V Net-_R306-Pad2_ LIMITER_IND_SRC /POWER-AMP/limit_ind /POWER-AMP/+15V RC4558_IMPL
XU501 Net-_XU501-Pad1_ Net-_XU501-Pad1_ /POWER-AMP/ptcsc_so /POWER-AMP/-15V Net-_C502-Pad1_ Net-_R516-Pad2_ /POWER-AMP/ptcoc_so /POWER-AMP/+15V RC4558_IMPL
R4031 V_OUT_INT Net-_Q402-Pad2_ 15k
R4021 Net-_C401-Pad2_ 0 15k
R405 /POWER-AMP/+75V Net-_Q401-Pad1_ 2.2k
C401 Net-_C401-Pad1_ Net-_C401-Pad2_ 10uF
Q401 Net-_Q401-Pad1_ Net-_C401-Pad2_ Net-_Q401-Pad3_ 2N5551
Q402 /POWER-AMP/+75V Net-_Q402-Pad2_ Net-_Q401-Pad3_ 2N5551
D201 V_OUT_INT Net-_D201-Pad2_ 1N4007
Q201 /POWER-AMP/vlmp Net-_D202-Pad1_ Net-_D201-Pad2_ 2N5401
D202 Net-_D202-Pad1_ Net-_D202-Pad2_ 1N4007
R4072 Net-_R4072-Pad1_ Net-_R4071-Pad1_ 8.2k
R4073 Net-_R4073-Pad1_ Net-_R4072-Pad1_ 8.2k
R4074 Net-_D401-Pad2_ Net-_R4073-Pad1_ 8.2k
R4071 Net-_R4071-Pad1_ 0 8.2k
C403 Net-_Q401-Pad1_ /POWER-AMP/vasp 56pF
C402 Net-_C402-Pad1_ 0 220uF
R404 Net-_C402-Pad1_ Net-_Q402-Pad2_ 330
R4091 /POWER-AMP/+75V Net-_Q404-Pad3_ 220
Q407 /POWER-AMP/+75V /POWER-AMP/vasp Net-_Q407-Pad3_ MJE15032
Q404 /POWER-AMP/vasp Net-_Q401-Pad1_ Net-_Q404-Pad3_ MJE350
R411 Net-_Q405-Pad2_ /POWER-AMP/vasp 680
RT402 /POWER-AMP/vasp Net-_R412-Pad1_ 5k
R412 Net-_R412-Pad1_ Net-_Q405-Pad2_ 680
R40141 Net-_R40141-Pad1_ 0 3.9k
R40144 Net-_D402-Pad2_ Net-_R40143-Pad1_ 3.9k
R40142 Net-_R40142-Pad1_ Net-_R40141-Pad1_ 3.9k
R40143 Net-_R40143-Pad1_ Net-_R40142-Pad1_ 3.9k
R413 /POWER-AMP/vasp Net-_R412-Pad1_ 5.6k
R40161 Net-_Q408-Pad3_ Net-_Q407-Pad3_ 220
Q405 /POWER-AMP/vasn Net-_Q405-Pad2_ /POWER-AMP/vasp MJE350
D205 Net-_D205-Pad1_ Net-_D205-Pad2_ 1N4007
D208 Net-_D208-Pad1_ /POWER-AMP/+15V 1N4007
D207 Net-_D207-Pad1_ /POWER-AMP/+15V 1N4007
D206 /POWER-AMP/-75V Net-_D205-Pad1_ 1N4743
D209 /POWER-AMP/-15V Net-_D207-Pad1_ 1N4007
D210 /POWER-AMP/-15V Net-_D208-Pad1_ 1N4007
R204 Net-_D207-Pad1_ /POWER-AMP/vlmp 10k
R203 Net-_D205-Pad1_ 0 33k
R205 Net-_D208-Pad1_ /POWER-AMP/vlmn 10k
R202 0 Net-_D202-Pad2_ 33k
R206 Net-_D207-Pad1_ 0 10k
XU101 Net-_R105-Pad2_ Net-_R105-Pad2_ Net-_C101-Pad2_ /POWER-AMP/-15V Net-_C102-Pad2_ Net-_R107-Pad1_ Net-_R107-Pad1_ /POWER-AMP/+15V RC4558_IMPL
C101 0 Net-_C101-Pad2_ 100pF
R103 -BAL_IN Net-_C102-Pad2_ 10k
R102 0 Net-_C101-Pad2_ 10k
R504 Net-_D505-Pad2_ /POWER-AMP/ptcsc_so 100k
R502 Net-_D501-Pad1_ /POWER-AMP/ptcsl 10k
D504 Net-_D503-Pad1_ Net-_D504-Pad2_ 1N4007
Q502 Net-_D506-Pad2_ Net-_D504-Pad2_ P_OUTPUT 2N5551
D506 Net-_D506-Pad1_ Net-_D506-Pad2_ 1N4007
R505 /POWER-AMP/ptcsc_so Net-_D506-Pad1_ 100k
C102 0 Net-_C102-Pad2_ 100pF
R104 0 Net-_C102-Pad2_ 10k
Q501 Net-_D505-Pad1_ Net-_D502-Pad1_ P_OUTPUT 2N5401
R501 P_OUTPUT /POWER-AMP/ptcsl 0.1
D505 Net-_D505-Pad1_ Net-_D505-Pad2_ 1N4007
D502 Net-_D502-Pad1_ Net-_D501-Pad2_ 1N4007
D501 Net-_D501-Pad1_ Net-_D501-Pad2_ 1N4732
R509 0 Net-_Q504-Pad2_ 330k
R510 /POWER-AMP/-75V Net-_Q504-Pad2_ 1.8k
R508 /POWER-AMP/+75V Net-_Q503-Pad2_ 1.8k
R507 Net-_Q503-Pad2_ 0 330k
D508 /POWER-AMP/-15V /POWER-AMP/ptcsc_so 1N4007
D507 /POWER-AMP/ptcsc_so /POWER-AMP/+15V 1N4007
D503 Net-_D503-Pad1_ Net-_D503-Pad2_ 1N4732
R503 /POWER-AMP/ptcsl Net-_D503-Pad2_ 10k
R506 /POWER-AMP/ptcsc_so 0 10k
C501 /POWER-AMP/ptcsc_so 0 0.1uF
D211 0 Net-_D211-Pad2_ 1N4148
D203 Net-_D202-Pad2_ /POWER-AMP/+75V 1N4743
Q203 LIMITER_IND_SRC Net-_D211-Pad2_ 0 2N5551
R208 Net-_D208-Pad1_ /POWER-AMP/vlmao 10k
R209 /POWER-AMP/vlmao Net-_D211-Pad2_ 10k
C103 0 VOL_CTL 100pF
R110 VOL_CTL 0 10k
R106 0 Net-_R105-Pad1_ 10k
XU102 Net-_R108-Pad2_ Net-_R107-Pad2_ Net-_R105-Pad1_ /POWER-AMP/-15V VOL_CTL Net-_R201-Pad1_ Net-_R201-Pad1_ /POWER-AMP/+15V RC4558_IMPL
R109 VOL_SRC Net-_R108-Pad2_ 47
R105 Net-_R105-Pad1_ Net-_R105-Pad2_ 10k
R107 Net-_R107-Pad1_ Net-_R107-Pad2_ 10k
R108 Net-_R107-Pad2_ Net-_R108-Pad2_ 10k
R101 +BAL_IN Net-_C101-Pad2_ 10k
R207 Net-_D208-Pad1_ 0 10k
C201 LIMITER_IND_SRC 0 220uF
R4194 Net-_Q4114-Pad3_ V_OUT_INT 0.47
D411 V_OUT_INT /POWER-AMP/+75V 10A03
R4193 Net-_Q4113-Pad3_ V_OUT_INT 0.47
R4192 Net-_Q4112-Pad3_ V_OUT_INT 0.47
R4017 V_OUT_INT /POWER-AMP/drvp 10
R4191 /POWER-AMP/voep1 V_OUT_INT 0.47
L401 V_OUT_INT P_OUTPUT 1uH
R4195 Net-_Q4115-Pad3_ V_OUT_INT 0.47
R4206 V_OUT_INT Net-_Q4125-Pad3_ 0.47
R421 V_OUT_INT Net-_C405-Pad2_ 10
C405 0 Net-_C405-Pad2_ 0.1uF
Q4121 /POWER-AMP/-75V /POWER-AMP/drvn /POWER-AMP/voen1 MJL21193
Q4122 /POWER-AMP/-75V /POWER-AMP/drvn Net-_Q4122-Pad3_ MJL21193
R4201 V_OUT_INT /POWER-AMP/voen1 0.47
R4018 /POWER-AMP/drvn V_OUT_INT 10
Q4114 /POWER-AMP/+75V /POWER-AMP/drvp Net-_Q4114-Pad3_ MJL21194
Q4115 /POWER-AMP/+75V /POWER-AMP/drvp Net-_Q4115-Pad3_ MJL21194
Q4113 /POWER-AMP/+75V /POWER-AMP/drvp Net-_Q4113-Pad3_ MJL21194
Q4112 /POWER-AMP/+75V /POWER-AMP/drvp Net-_Q4112-Pad3_ MJL21194
Q4111 /POWER-AMP/+75V /POWER-AMP/drvp /POWER-AMP/voep1 MJL21194
Q409 /POWER-AMP/+75V Net-_Q407-Pad3_ /POWER-AMP/drvp 2SC5200
R4081 Net-_Q403-Pad3_ Net-_R4081-Pad2_ 1.8k
R4082 Net-_R4081-Pad2_ /POWER-AMP/-75V 47
Q406 /POWER-AMP/vasn Net-_D402-Pad2_ Net-_Q406-Pad3_ MJE340
R40151 Net-_Q406-Pad3_ Net-_R40151-Pad2_ 680
D402 /POWER-AMP/-75V Net-_D402-Pad2_ 1N4732
R304 Net-_R302-Pad2_ Net-_D302-Pad2_ 10k
R301 0 Net-_R301-Pad2_ 1k
R302 Net-_R301-Pad2_ Net-_R302-Pad2_ 100k
D302 0 Net-_D302-Pad2_ 1N4148
Q301 /POWER-AMP/s_ind Net-_D302-Pad2_ 0 2N5551
D301 /POWER-AMP/+15V Net-_D301-Pad2_ LED_yellow
R305 Net-_D301-Pad2_ /POWER-AMP/s_ind 2.7k
Q403 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q403-Pad3_ MJE340
D401 /POWER-AMP/-75V Net-_D401-Pad2_ 1N4732
D204 Net-_D204-Pad1_ V_OUT_INT 1N4007
Q202 /POWER-AMP/vlmn Net-_D205-Pad2_ Net-_D204-Pad1_ 2N5551
R514 V_OUT_INT Net-_C502-Pad1_ 100k
D303 Net-_D303-Pad1_ 0 LED_yellow
R308 /POWER-AMP/limit_ind Net-_D303-Pad1_ 3.3k
R306 /POWER-AMP/+15V Net-_R306-Pad2_ 10k
R307 Net-_R306-Pad2_ 0 100k
C301 /POWER-AMP/s_ind 0 10uF
R513 Net-_XU501-Pad1_ Net-_D511-Pad1_ 10k
R515 Net-_C502-Pad1_ 0 100k
D509 Net-_C502-Pad1_ /POWER-AMP/+15V 1N4007
R518 /POWER-AMP/ptcoc_so Net-_D513-Pad1_ 10k
D510 /POWER-AMP/-15V Net-_C502-Pad1_ 1N4007
D512 Net-_D512-Pad1_ Net-_D511-Pad1_ 1N4148
D511 Net-_D511-Pad1_ Net-_D511-Pad2_ 1N4148
R520 /POWER-AMP/+15V Net-_Q506-Pad2_ 10k
R519 Net-_Q506-Pad2_ Net-_Q505-Pad1_ 10k
Q505 Net-_Q505-Pad1_ 0 Net-_D512-Pad1_ 2N5551
Q506 Net-_Q506-Pad1_ Net-_Q506-Pad2_ /POWER-AMP/+15V 2N5401
C404 /POWER-AMP/vasn /POWER-AMP/vasp 0.1uF
R410 Net-_Q405-Pad2_ /POWER-AMP/vasn 2.2k
Q410 /POWER-AMP/-75V Net-_Q408-Pad3_ /POWER-AMP/drvn 2SA1943
R512 Net-_Q504-Pad1_ /POWER-AMP/ptcsc_so 10k
Q504 Net-_Q504-Pad1_ Net-_Q504-Pad2_ /POWER-AMP/-75V 2N5551
C502 Net-_C502-Pad1_ 0 220uF
R511 Net-_Q503-Pad1_ /POWER-AMP/ptcsc_so 10k
Q503 Net-_Q503-Pad1_ Net-_Q503-Pad2_ /POWER-AMP/+75V 2N5401
D514 Net-_D512-Pad1_ Net-_D513-Pad1_ 1N4148
R516 0 Net-_R516-Pad2_ 10k
R517 Net-_R516-Pad2_ /POWER-AMP/ptcoc_so 100k
R40152 Net-_R40151-Pad2_ /POWER-AMP/-75V 100
Q408 /POWER-AMP/-75V /POWER-AMP/vasn Net-_Q408-Pad3_ MJE15033
Q4124 /POWER-AMP/-75V /POWER-AMP/drvn Net-_Q4124-Pad3_ MJL21193
Q4125 /POWER-AMP/-75V /POWER-AMP/drvn Net-_Q4125-Pad3_ MJL21193
Q4123 /POWER-AMP/-75V /POWER-AMP/drvn Net-_Q4123-Pad3_ MJL21193
R4203 V_OUT_INT Net-_Q4123-Pad3_ 0.47
R4204 V_OUT_INT Net-_Q4124-Pad3_ 0.47
R4202 V_OUT_INT Net-_Q4122-Pad3_ 0.47
D412 /POWER-AMP/-75V V_OUT_INT 10A03
R524 /POWER-AMP/+24V Net-_C503-Pad1_ 100k
Q508 /POWER-AMP/+24V Net-_C503-Pad1_ Net-_Q508-Pad3_ 2N5551
D515 /POWER-AMP/PTC_RL /POWER-AMP/+24V 1N4002
R525 Net-_Q508-Pad3_ Net-_Q509-Pad2_ 4.7k
Q509 /POWER-AMP/PTC_RL Net-_Q509-Pad2_ 0 TIP41C
C503 Net-_C503-Pad1_ 0 1uF
R526 Net-_Q508-Pad3_ 0 4.7k
D518 Net-_D518-Pad1_ 0 LED_yellow
S1 /POWER-AMP/ptcsl L_OUTPUT /POWER-AMP/+24V /POWER-AMP/PTC_RL sw1 ON
R528 /POWER-AMP/ptcsl 0 100k
R523 Net-_D511-Pad2_ Net-_D516-Pad2_ 100k
R522 Net-_D511-Pad2_ 0 100k
D513 Net-_D513-Pad1_ Net-_D511-Pad2_ 1N4148
R521 Net-_Q506-Pad1_ Net-_D511-Pad2_ 10k
Q507 Net-_C503-Pad1_ Net-_D511-Pad2_ 0 2N5551
D517 0 Net-_C504-Pad2_ 1N4148
R527 /POWER-AMP/PTC_RL Net-_D518-Pad1_ 10k
C504 /POWER-AMP/PTC_RL Net-_C504-Pad2_ 47uF
D516 Net-_C504-Pad2_ Net-_D516-Pad2_ 1N4148
.end
