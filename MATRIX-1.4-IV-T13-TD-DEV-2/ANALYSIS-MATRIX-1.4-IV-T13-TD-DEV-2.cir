.title MATRIX 1.4 IV T13 1400W RMS TD-CLASS - DEVELOPMENT RELEASE 2
.include "spice_models/model.lib"
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
V11 +120V 0 DC 120V
V12 0 -120V DC 120V
R901 VPOUT 0 4
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
Q4143 VSAVN DRVN2 Net-_Q4143-Pad3_ 2SA1943
Q4145 VSAVN DRVN2 Net-_Q4145-Pad3_ 2SA1943
Q4144 VSAVN DRVN2 Net-_Q4144-Pad3_ 2SA1943
R4193 VMOUT Net-_Q4143-Pad3_ 0.33
Q4146 VSAVN DRVN2 Net-_Q4146-Pad3_ 2SA1943
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
C406 0 Net-_C406-Pad2_ 0.1uF
R420 VMOUT Net-_C406-Pad2_ 10
D403 VSAVN VMOUT MURF1560
R707 VSTCN Net-_Q705-Pad2_ 150
Q704 VSTCN Net-_Q703-Pad3_ VSAVN 2SA1943
R706 VSTCN -120V 1
D706 Net-_D706-Pad1_ VSTAN BAV21
Q705 VSTAN Net-_Q705-Pad2_ -120V 2N5551
Q710 VSGN Net-_Q709-Pad3_ -120V 2N5551
XQ7011 VSFN VSGN -120V IRF640
R711 Net-_Q708-Pad3_ VSGN 15
Q708 0 VSGZN Net-_Q708-Pad3_ 2N5551
D708 -120V VSGZN 1N4742
Q709 VSGN Net-_D707-Pad1_ Net-_Q709-Pad3_ 2N5551
R713 Net-_Q709-Pad3_ -120V 27k
D709 VSFN 0 MURF1560
R7102 VSGZN 0 33k
R7121 0 Net-_D707-Pad1_ 33k
R7122 0 Net-_D707-Pad1_ 33k
R7081 Net-_D706-Pad1_ 0 33k
Q4142 VSAVN DRVN2 Net-_Q4142-Pad3_ 2SA1943
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
Q4141 VSAVN DRVN2 Net-_Q4141-Pad3_ 2SA1943
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
R714 VSFN Net-_C703-Pad2_ 680
C704 -120V VSAVN 1uF
L701 VSAVN VSFN 10uH
XQ7012 VSFN VSGN -120V IRF640
C703 VSAVN Net-_C703-Pad2_ 2200pF
Q707 VSGZN Net-_Q706-Pad3_ -120V 2N5551
R709 -120V Net-_Q706-Pad3_ 27k
R7082 Net-_D706-Pad1_ 0 33k
R7101 VSGZN 0 33k
Q706 VSGZN Net-_D706-Pad1_ Net-_Q706-Pad3_ 2N5551
D707 Net-_D707-Pad1_ VSTAN BAV21
R4074 0 Net-_D401-Pad2_ 56k
Q407 VASN Net-_Q407-Pad2_ VASP MJE350
R411 Net-_Q407-Pad2_ VASP 390
Q702 -120V Net-_C702-Pad2_ Net-_Q702-Pad3_ MJE350
D704 Net-_D704-Pad1_ -120V MURF1560
D705 VSTCN Net-_D704-Pad1_ MURF1560
R4141 Net-_Q408-Pad3_ -120V 470
R4082 Net-_Q405-Pad3_ -120V 47k
R4142 Net-_Q408-Pad3_ -120V 47k
Q408 VASN Net-_D401-Pad2_ Net-_Q408-Pad3_ MJE340
D401 -120V Net-_D401-Pad2_ 1N4732
R703 0 Net-_C701-Pad1_ 47k
D702 Net-_C701-Pad1_ VMOUT 1N4007
R704 VSAVN Net-_Q702-Pad3_ 470
R705 VSAVN Net-_Q703-Pad3_ 18
Q703 -120V Net-_Q702-Pad3_ Net-_Q703-Pad3_ MJE15033
R4151 DRVN1 DRVP1 120
Q701 0 Net-_C701-Pad1_ Net-_D703-Pad2_ 2N5551
Q412 VSAVN DRVN1 DRVN2 2SA1943
C409 -120V 0 0.1uF
Q405 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q405-Pad3_ MJE340
R4081 Net-_Q405-Pad3_ -120V 470
C410 0 -120V 10uF
R410 Net-_Q407-Pad2_ VASN 1.2k
C405 VASN VASP 0.1uF
R4072 0 Net-_D401-Pad2_ 56k
R4073 0 Net-_D401-Pad2_ 56k
R4071 0 Net-_D401-Pad2_ 56k
Q410 -120V VASN DRVN1 MJE15033
C702 -120V Net-_C702-Pad2_ 180pF
R701 Net-_D701-Pad2_ -120V 1.2k
D703 Net-_C702-Pad2_ Net-_D703-Pad2_ 1N4734
R702 Net-_C701-Pad2_ Net-_C702-Pad2_ 47k
C701 Net-_C701-Pad1_ Net-_C701-Pad2_ 4.7uF
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R4032 VMOUT Net-_Q402-Pad2_ 270k
R4031 VMOUT Net-_Q402-Pad2_ 15k
R603 Net-_C601-Pad2_ 0 47k
Q601 0 Net-_C601-Pad2_ Net-_D603-Pad1_ 2N5401
Q411 VSAVP DRVP1 DRVP2 2SC5200
D602 VMOUT Net-_C601-Pad2_ 1N4007
R413 VASP Net-_R412-Pad1_ 2.2k
R401 Net-_C402-Pad2_ Net-_C401-Pad2_ 180
C401 MAIN_IN Net-_C401-Pad2_ 10uF
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 390
RT401 VASP Net-_R412-Pad1_ 5k
C602 Net-_C602-Pad1_ +120V 180pF
R605 Net-_Q603-Pad3_ VSAVP 18
D604 +120V Net-_D604-Pad2_ MURF1560
D605 Net-_D604-Pad2_ VSTCP MURF1560
R604 Net-_Q602-Pad3_ VSAVP 470
Q603 +120V Net-_Q602-Pad3_ Net-_Q603-Pad3_ MJE15032
D603 Net-_D603-Pad1_ Net-_C602-Pad1_ 1N4734
Q602 +120V Net-_C602-Pad1_ Net-_Q602-Pad3_ MJE340
C407 0 +120V 0.1uF
C408 +120V 0 10uF
R4062 +120V Net-_Q404-Pad3_ 470
Q404 Net-_C404-Pad1_ Net-_Q402-Pad1_ Net-_Q404-Pad3_ MPSA92
C601 Net-_C601-Pad1_ Net-_C601-Pad2_ 4.7uF
R4092 +120V Net-_Q406-Pad3_ 820
C404 Net-_C404-Pad1_ VASP 220pF
Q406 VASP Net-_C404-Pad1_ Net-_Q406-Pad3_ MJE350
Q409 +120V VASP DRVP1 MJE15032
R601 +120V Net-_D601-Pad1_ 1.2k
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
R602 Net-_C601-Pad1_ Net-_C602-Pad1_ 47k
Q401 Net-_C404-Pad1_ Net-_C402-Pad2_ Net-_Q401-Pad3_ MPSA42
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ MPSA42
R4021 Net-_C402-Pad2_ 0 15k
C402 0 Net-_C402-Pad2_ 220pF
C403 Net-_C403-Pad1_ 0 220uF
R404 Net-_Q402-Pad2_ Net-_C403-Pad1_ 180
R4022 Net-_C402-Pad2_ 0 270k
R4061 +120V Net-_Q404-Pad3_ 56
R4091 +120V Net-_Q406-Pad3_ 150
R4051 +120V Net-_Q403-Pad3_ 56
R4052 +120V Net-_Q403-Pad3_ 470
Q403 Net-_Q402-Pad1_ Net-_Q402-Pad1_ Net-_Q403-Pad3_ MPSA92
R6102 VSGZP 0 33k
D607 VSTAP Net-_D607-Pad2_ BAV21
Q607 VSGZP Net-_Q606-Pad3_ +120V 2N5401
R6101 VSGZP 0 33k
R6082 Net-_D606-Pad2_ 0 33k
R6081 Net-_D606-Pad2_ 0 33k
Q606 VSGZP Net-_D606-Pad2_ Net-_Q606-Pad3_ 2N5401
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
Q4136 VSAVP DRVP2 Net-_Q4136-Pad3_ 2SC5200
D402 VMOUT VSAVP MURF1560
R6121 Net-_D607-Pad2_ 0 33k
R6122 Net-_D607-Pad2_ 0 33k
L401 VPOUT VMOUT 1uH
Q608 0 VSGZP Net-_Q608-Pad3_ 2N5401
R611 VSGP Net-_Q608-Pad3_ 15
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
Q4131 VSAVP DRVP2 Net-_Q4131-Pad3_ 2SC5200
R417 DRVN2 VMOUT 5.6
R416 VMOUT DRVP2 5.6
Q4132 VSAVP DRVP2 Net-_Q4132-Pad3_ 2SC5200
R609 +120V Net-_Q606-Pad3_ 27k
D608 VSGZP +120V 1N4742
Q610 VSGP Net-_Q609-Pad3_ +120V 2N5401
R613 +120V Net-_Q609-Pad3_ 27k
Q609 VSGP Net-_D607-Pad2_ Net-_Q609-Pad3_ 2N5401
D609 0 VSFP MURF1560
XQ6011 VSFP VSGP +120V IRF9640
Q4134 VSAVP DRVP2 Net-_Q4134-Pad3_ 2SC5200
Q4133 VSAVP DRVP2 Net-_Q4133-Pad3_ 2SC5200
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
Q4135 VSAVP DRVP2 Net-_Q4135-Pad3_ 2SC5200
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
L601 VSAVP VSFP 10uH
C604 VSAVP +120V 1uF
R614 VSFP Net-_C603-Pad2_ 680
XQ6012 VSFP VSGP +120V IRF9640
C603 VSAVP Net-_C603-Pad2_ 2200pF
R606 +120V VSTCP 1
Q605 VSTAP Net-_Q605-Pad2_ +120V 2N5401
R607 VSTCP Net-_Q605-Pad2_ 150
Q604 VSTCP Net-_Q603-Pad3_ VSAVP 2SC5200
D606 VSTAP Net-_D606-Pad2_ BAV21
.end
