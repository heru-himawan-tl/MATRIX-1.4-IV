.title 1400W RMS FOR 4-OHMS CLASS-TD AUDIO POWER AMPLIFIER - DEVELOPMENT RELEASE 2
.include "spice_models/model.lib"
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
V11 +120V 0 DC 120V
V12 0 -120V DC 120V
R_LOAD1 VPOUT 0 4
R4061 +120V Net-_Q404-Pad3_ 56
C408 +120V 0 10uF
C407 0 +120V 0.1uF
R4062 +120V Net-_Q404-Pad3_ 470
Q404 Net-_C404-Pad1_ Net-_Q402-Pad1_ Net-_Q404-Pad3_ MPSA92
R413 VASP Net-_R412-Pad1_ 2.2k
RT401 VASP Net-_R412-Pad1_ 5k
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 390
R4031 VMOUT Net-_Q402-Pad2_ 15k
C403 Net-_C403-Pad1_ 0 220uF
R404 Net-_Q402-Pad2_ Net-_C403-Pad1_ 180
C402 0 Net-_C402-Pad2_ 220pF
Q401 Net-_C404-Pad1_ Net-_C402-Pad2_ Net-_Q401-Pad3_ MPSA42
R4021 Net-_C402-Pad2_ 0 15k
R4022 Net-_C402-Pad2_ 0 270k
C401 MAIN_IN Net-_C401-Pad2_ 10uF
R401 Net-_C402-Pad2_ Net-_C401-Pad2_ 680
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ MPSA42
C404 Net-_C404-Pad1_ VASP 220pF
R4051 +120V Net-_Q403-Pad3_ 56
R4052 +120V Net-_Q403-Pad3_ 470
Q403 Net-_Q402-Pad1_ Net-_Q402-Pad1_ Net-_Q403-Pad3_ MPSA92
R4032 VMOUT Net-_Q402-Pad2_ 270k
R4091 +120V Net-_Q406-Pad3_ 150
Q406 VASP Net-_C404-Pad1_ Net-_Q406-Pad3_ MJE350
R4092 +120V Net-_Q406-Pad3_ 820
R601 +120V Net-_D601-Pad1_ 1.5k
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
R602 Net-_C601-Pad1_ Net-_Q602-Pad2_ 47k
D603 Net-_D603-Pad1_ Net-_Q602-Pad2_ 1N4730
C602 Net-_Q602-Pad2_ +120V 330pF
C601 Net-_C601-Pad1_ Net-_D602-Pad2_ 10uF
Q409 +120V VASP DRVP1 MJE15032
D602 DRVP2 Net-_D602-Pad2_ 1N4007
Q601 0 Net-_D602-Pad2_ Net-_D603-Pad1_ 2N5401
R603 Net-_D602-Pad2_ 0 47k
Q711 0 VSGZN Net-_Q711-Pad3_ 2N5551
R713 Net-_Q711-Pad3_ VSGN 15
C704 -120V VSAVN 1uF
XQ7012 VSFN VSGN -120V IRF640
L701 VSAVN VSFN 10uH
D712 VSFN 0 MURF1560
XQ7011 VSFN VSGN -120V IRF640
Q713 VSGN Net-_Q712-Pad3_ -120V 2N5551
C703 VSAVN Net-_C703-Pad2_ 2200pF
R716 VSFN Net-_C703-Pad2_ 680
R7122 VSGZN 0 33k
R7121 VSGZN 0 33k
Q708 -120V VSTAN0 VSTAN2 2N5401
R7141 VSTAN2 0 33k
R7142 VSTAN2 0 33k
R7102 VSTAN1 0 33k
R711 -120V Net-_Q709-Pad3_ 27k
Q709 VSGZN VSTAN1 Net-_Q709-Pad3_ 2N5551
Q710 VSGZN Net-_Q709-Pad3_ -120V 2N5551
D711 -120V VSGZN 1N4742
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
Q4145 VSAVN DRVN2 Net-_Q4145-Pad3_ 2SA1943
Q4146 VSAVN DRVN2 Net-_Q4146-Pad3_ 2SA1943
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
D403 VSAVN VMOUT MURF1560
R420 VMOUT Net-_C406-Pad2_ 10
C406 0 Net-_C406-Pad2_ 0.1uF
L401 VPOUT VMOUT 1uH
D402 VMOUT VSAVP MURF1560
Q611 0 VSGZP Net-_Q611-Pad3_ 2N5401
R613 VSGP Net-_Q611-Pad3_ 15
D611 VSGZP +120V 1N4742
Q609 VSGZP VSTAP1 Net-_Q609-Pad3_ 2N5401
Q610 VSGZP Net-_Q609-Pad3_ +120V 2N5401
R6121 VSGZP 0 33k
R6122 VSGZP 0 33k
D612 0 VSFP MURF1560
XQ6012 VSFP VSGP +120V IRF9640
C604 VSAVP +120V 1uF
L601 VSAVP VSFP 10uH
C603 VSAVP Net-_C603-Pad2_ 2200pF
R616 VSFP Net-_C603-Pad2_ 680
XQ6011 VSFP VSGP +120V IRF9640
Q613 VSGP Net-_Q612-Pad3_ +120V 2N5401
Q612 VSGP VSTAP2 Net-_Q612-Pad3_ 2N5401
R615 +120V Net-_Q612-Pad3_ 27k
R611 +120V Net-_Q609-Pad3_ 27k
Q712 VSGN VSTAN2 Net-_Q712-Pad3_ 2N5551
R715 Net-_Q712-Pad3_ -120V 27k
R4193 VMOUT Net-_Q4143-Pad3_ 0.15
Q4143 VSAVN DRVN2 Net-_Q4143-Pad3_ 2SA1943
R7091 VSTAN0 0 33k
R7092 VSTAN0 0 33k
Q4144 VSAVN DRVN2 Net-_Q4144-Pad3_ 2SA1943
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
R7101 VSTAN1 0 33k
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
Q4142 VSAVN DRVN2 Net-_Q4142-Pad3_ 2SA1943
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
Q4141 VSAVN DRVN2 Net-_Q4141-Pad3_ 2SA1943
Q412 VSAVN DRVN1 DRVN2 2SA1943
R417 DRVN2 VMOUT 5.6
R707 VSTCN -120V 1
R708 VSTCN Net-_Q706-Pad2_ 150
D707 Net-_D707-Pad1_ -120V MURF1560
D708 VSTCN Net-_D707-Pad1_ MURF1560
Q703 -120V Net-_Q703-Pad2_ Net-_Q703-Pad3_ MJE350
R705 Net-_Q703-Pad2_ -120V 47k
D710 VSTAN0 VSTAN2 1N4007
Q707 -120V VSTAN0 VSTAN1 2N5401
D709 VSTAN0 VSTAN1 1N4007
Q706 VSTAN0 Net-_Q706-Pad2_ -120V 2N5551
Q705 VSTCN VSTDRVN2 VSAVN 2SA1943
Q704 -120V VSTDRVN1 VSTDRVN2 MJE15033
D705 Net-_Q703-Pad2_ 0 1N4742
D706 VSTDRVN1 Net-_Q703-Pad3_ 1N4007
R706 VSAVN VSTDRVN2 18
R4082 Net-_Q405-Pad3_ -120V 47k
C410 0 -120V 10uF
C409 -120V 0 0.1uF
Q405 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q405-Pad3_ MJE340
R4081 Net-_Q405-Pad3_ -120V 470
D401 -120V Net-_D401-Pad2_ 1N4732
R4142 Net-_Q408-Pad3_ -120V 47k
Q408 VASN Net-_D401-Pad2_ Net-_Q408-Pad3_ MJE340
R4074 0 Net-_D401-Pad2_ 56k
R4141 Net-_Q408-Pad3_ -120V 470
R701 Net-_D701-Pad2_ -120V 1.5k
C702 -120V Net-_C702-Pad2_ 330pF
Q702 -120V Net-_C702-Pad2_ Net-_Q702-Pad3_ MJE350
D703 Net-_C702-Pad2_ Net-_D703-Pad2_ 1N4730
D704 VSTDRVN1 Net-_Q702-Pad3_ 1N4007
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R702 Net-_C701-Pad2_ Net-_C702-Pad2_ 47k
C701 Net-_C701-Pad1_ Net-_C701-Pad2_ 10uF
Q701 0 Net-_C701-Pad1_ Net-_D703-Pad2_ 2N5551
Q407 VASN Net-_Q407-Pad2_ VASP MJE350
R411 Net-_Q407-Pad2_ VASP 390
C405 VASN VASP 0.1uF
Q410 -120V VASN DRVN1 MJE15033
R4071 0 Net-_D401-Pad2_ 56k
R410 Net-_Q407-Pad2_ VASN 1.2k
R4073 0 Net-_D401-Pad2_ 56k
R4072 0 Net-_D401-Pad2_ 56k
R704 VSAVN VSTDRVN1 470
D702 Net-_C701-Pad1_ DRVN2 1N4007
R4151 DRVN1 DRVP1 120
R703 Net-_C701-Pad1_ 0 47k
D604 Net-_Q602-Pad3_ VSTDRVP1 1N4007
Q603 +120V Net-_Q603-Pad2_ Net-_Q603-Pad3_ MJE340
D606 Net-_Q603-Pad3_ VSTDRVP1 1N4007
Q602 +120V Net-_Q602-Pad2_ Net-_Q602-Pad3_ MJE340
R605 +120V Net-_Q603-Pad2_ 47k
Q606 VSTAP0 Net-_Q606-Pad2_ +120V 2N5401
R6091 VSTAP0 0 33k
Q607 +120V VSTAP0 VSTAP1 2N5551
D609 VSTAP1 VSTAP0 1N4007
Q4131 VSAVP DRVP2 Net-_Q4131-Pad3_ 2SC5200
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
R416 VMOUT DRVP2 5.6
Q4133 VSAVP DRVP2 Net-_Q4133-Pad3_ 2SC5200
Q4132 VSAVP DRVP2 Net-_Q4132-Pad3_ 2SC5200
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
Q4134 VSAVP DRVP2 Net-_Q4134-Pad3_ 2SC5200
Q4135 VSAVP DRVP2 Net-_Q4135-Pad3_ 2SC5200
R6102 VSTAP1 0 33k
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
Q4136 VSAVP DRVP2 Net-_Q4136-Pad3_ 2SC5200
R6092 VSTAP0 0 33k
R6101 VSTAP1 0 33k
Q608 +120V VSTAP0 VSTAP2 2N5551
D610 VSTAP2 VSTAP0 1N4007
R6141 VSTAP2 0 33k
R6142 VSTAP2 0 33k
Q411 VSAVP DRVP1 DRVP2 2SC5200
R606 VSTDRVP2 VSAVP 18
R604 VSTDRVP1 VSAVP 470
D605 0 Net-_Q603-Pad2_ 1N4742
Q604 +120V VSTDRVP1 VSTDRVP2 MJE15032
Q605 VSTCP VSTDRVP2 VSAVP 2SC5200
R608 VSTCP Net-_Q606-Pad2_ 150
D607 +120V Net-_D607-Pad2_ MURF1560
D608 Net-_D607-Pad2_ VSTCP MURF1560
R607 +120V VSTCP 1
.end
