.title MATRIX 1.4 IV T13 1400W RMS TD-CLASS - DEVELOPMENT RELEASE 1
.include "spice_models/model.lib"
V12 0 /POWER-AMP/-120V DC 120V
V32 0 /-15V DC 15V
V31 /+15V 0 DC 15V
V11 /POWER-AMP/+120V 0 DC 120V
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
Rdummy1 VPOUT 0 4
R603 Net-_Q601-Pad2_ 0 22k
D603 Net-_Q601-Pad3_ Net-_C602-Pad1_ 1N4734
D602 VMOUT Net-_Q601-Pad2_ 1N4007
R602 Net-_R602-Pad1_ Net-_C602-Pad1_ 22k
C601 Net-_R602-Pad1_ Net-_Q601-Pad2_ 4.7uF
Q601 0 Net-_Q601-Pad2_ Net-_Q601-Pad3_ 2N5401
Q4131 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4131-Pad3_ 2SC5200
Q411 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 /POWER-AMP/DRVP2 2SC5200
Q4133 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4133-Pad3_ 2SC5200
Q4132 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4132-Pad3_ 2SC5200
D607 /POWER-AMP/VSGZP /POWER-AMP/+120V 1N4746
Q4134 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4134-Pad3_ 2SC5200
Q4136 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4136-Pad3_ 2SC5200
Q4135 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4135-Pad3_ 2SC5200
Q605 /POWER-AMP/VSGZP Net-_R607-Pad1_ Net-_Q605-Pad3_ 2N5401
Q604 Net-_Q604-Pad1_ Net-_R606-Pad2_ /POWER-AMP/+120V 2N5401
D608 Net-_Q604-Pad1_ Net-_D608-Pad2_ BAV21
R611 Net-_D608-Pad2_ 0 15k
R606 /POWER-AMP/VSTCP Net-_R606-Pad2_ 150
Q606 /POWER-AMP/VSGZP Net-_Q605-Pad3_ /POWER-AMP/+120V 2N5401
D606 Net-_Q604-Pad1_ Net-_R607-Pad1_ BAV21
R608 /POWER-AMP/+120V Net-_Q605-Pad3_ 27k
R604 Net-_Q602-Pad3_ /POWER-AMP/VSAVP 120
R601 /POWER-AMP/+120V Net-_R601-Pad2_ 1.2k
D601 Net-_R601-Pad2_ Net-_R602-Pad1_ 1N4007
D605 Net-_D604-Pad2_ /POWER-AMP/VSTCP MURF1560
Q603 /POWER-AMP/VSTCP Net-_Q602-Pad3_ /POWER-AMP/VSAVP 2SC5200
D604 /POWER-AMP/+120V Net-_D604-Pad2_ MURF1560
R605 /POWER-AMP/+120V /POWER-AMP/VSTCP 1
C602 Net-_C602-Pad1_ /POWER-AMP/+120V 100pF
Q602 /POWER-AMP/+120V Net-_C602-Pad1_ Net-_Q602-Pad3_ MJE15032
XQ6012 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
XQ6011 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
L601 /POWER-AMP/VSAVP /POWER-AMP/VSFP 10uH
C604 /POWER-AMP/VSAVP /POWER-AMP/+120V 1uF
R610 /POWER-AMP/VSGP Net-_Q607-Pad3_ 15
Q607 0 /POWER-AMP/VSGZP Net-_Q607-Pad3_ 2N5401
Q608 /POWER-AMP/VSGP Net-_D608-Pad2_ Net-_Q609-Pad2_ 2N5401
R612 /POWER-AMP/+120V Net-_Q609-Pad2_ 27k
Q609 /POWER-AMP/VSGP Net-_Q609-Pad2_ /POWER-AMP/+120V 2N5401
R4081 Net-_Q405-Pad3_ /POWER-AMP/-120V 470
C410 0 /POWER-AMP/-120V 10uF
Q405 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q405-Pad3_ MJE340
C409 /POWER-AMP/-120V 0 0.1uF
Q408 /POWER-AMP/VASN Net-_D401-Pad2_ Net-_Q408-Pad3_ MJE340
R4142 Net-_Q408-Pad3_ /POWER-AMP/-120V 47k
R4141 Net-_Q408-Pad3_ /POWER-AMP/-120V 470
D401 /POWER-AMP/-120V Net-_D401-Pad2_ 1N4732
R4074 0 Net-_D401-Pad2_ 56k
R4082 Net-_Q405-Pad3_ /POWER-AMP/-120V 47k
Q410 /POWER-AMP/-120V /POWER-AMP/VASN /POWER-AMP/DRVN1 MJE15033
R4072 0 Net-_D401-Pad2_ 56k
R4073 0 Net-_D401-Pad2_ 56k
R4071 0 Net-_D401-Pad2_ 56k
C405 /POWER-AMP/VASN /POWER-AMP/VASP 0.1uF
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 390
R411 Net-_Q407-Pad2_ /POWER-AMP/VASP 390
Q407 /POWER-AMP/VASN Net-_Q407-Pad2_ /POWER-AMP/VASP MJE350
RT401 /POWER-AMP/VASP Net-_R412-Pad1_ 5k
R410 Net-_Q407-Pad2_ /POWER-AMP/VASN 1.2k
D702 Net-_Q701-Pad2_ VMOUT 1N4007
Q412 /POWER-AMP/VSAVN /POWER-AMP/DRVN1 /POWER-AMP/DRVN2 2SA1943
R703 0 Net-_Q701-Pad2_ 22k
Q701 0 Net-_Q701-Pad2_ Net-_D703-Pad2_ 2N5551
D703 Net-_C702-Pad2_ Net-_D703-Pad2_ 1N4734
R417 /POWER-AMP/DRVN2 VMOUT 5.6
Q4141 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4141-Pad3_ 2SA1943
R416 VMOUT /POWER-AMP/DRVP2 5.6
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
Q4142 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4142-Pad3_ 2SA1943
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
Q4143 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4143-Pad3_ 2SA1943
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
R701 Net-_D701-Pad2_ /POWER-AMP/-120V 1.2k
D701 Net-_R702-Pad1_ Net-_D701-Pad2_ 1N4007
C701 Net-_Q701-Pad2_ Net-_R702-Pad1_ 4.7uF
R702 Net-_R702-Pad1_ Net-_C702-Pad2_ 22k
C702 /POWER-AMP/-120V Net-_C702-Pad2_ 100pF
Q702 /POWER-AMP/-120V Net-_C702-Pad2_ Net-_Q702-Pad3_ MJE15033
D704 Net-_D704-Pad1_ /POWER-AMP/-120V MURF1560
D705 /POWER-AMP/VSTCN Net-_D704-Pad1_ MURF1560
R705 /POWER-AMP/VSTCN /POWER-AMP/-120V 1
Q703 /POWER-AMP/VSTCN Net-_Q702-Pad3_ /POWER-AMP/VSAVN 2SA1943
R704 /POWER-AMP/VSAVN Net-_Q702-Pad3_ 120
R706 /POWER-AMP/VSTCN Net-_R706-Pad2_ 150
R4021 Net-_C402-Pad2_ 0 15k
R4022 Net-_C402-Pad2_ 0 270k
C402 0 Net-_C402-Pad2_ 220pF
C403 Net-_C403-Pad1_ 0 220uF
R404 Net-_Q402-Pad2_ Net-_C403-Pad1_ 180
Q401 Net-_C404-Pad1_ Net-_C402-Pad2_ Net-_Q401-Pad3_ MPSA42
R401 Net-_C402-Pad2_ Net-_C401-Pad2_ 180
C401 MAIN_IN Net-_C401-Pad2_ 10uF
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ MPSA42
Q404 Net-_C404-Pad1_ Net-_Q402-Pad1_ Net-_Q404-Pad3_ MPSA92
R4062 /POWER-AMP/+120V Net-_Q404-Pad3_ 470
C408 /POWER-AMP/+120V 0 10uF
C407 0 /POWER-AMP/+120V 0.1uF
R4032 VMOUT Net-_Q402-Pad2_ 270k
R4031 VMOUT Net-_Q402-Pad2_ 15k
R4061 /POWER-AMP/+120V Net-_Q404-Pad3_ 56
R4051 /POWER-AMP/+120V Net-_Q403-Pad3_ 56
Q403 Net-_Q402-Pad1_ Net-_Q402-Pad1_ Net-_Q403-Pad3_ MPSA92
Q406 /POWER-AMP/VASP Net-_C404-Pad1_ /POWER-AMP/VASDEP MJE350
R4092 /POWER-AMP/+120V /POWER-AMP/VASDEP 820
Q409 /POWER-AMP/+120V /POWER-AMP/VASP /POWER-AMP/DRVP1 MJE15032
R4151 /POWER-AMP/DRVN1 /POWER-AMP/DRVP1 120
R413 /POWER-AMP/VASP Net-_R412-Pad1_ 2.2k
C404 Net-_C404-Pad1_ /POWER-AMP/VASP 220pF
R4052 /POWER-AMP/+120V Net-_Q403-Pad3_ 470
R4091 /POWER-AMP/+120V /POWER-AMP/VASDEP 150
R710 Net-_R710-Pad1_ /POWER-AMP/VSGN 15
Q707 0 /POWER-AMP/VSGZN Net-_R710-Pad1_ 2N5551
D707 /POWER-AMP/-120V /POWER-AMP/VSGZN 1N4746
R709 /POWER-AMP/VSGZN 0 15k
Q705 /POWER-AMP/VSGZN Net-_R707-Pad1_ Net-_Q706-Pad2_ 2N5551
D706 Net-_R707-Pad1_ Net-_Q704-Pad1_ BAV21
Q706 /POWER-AMP/VSGZN Net-_Q706-Pad2_ /POWER-AMP/-120V 2N5551
Q704 Net-_Q704-Pad1_ Net-_R706-Pad2_ /POWER-AMP/-120V 2N5551
R708 /POWER-AMP/-120V Net-_Q706-Pad2_ 27k
R707 Net-_R707-Pad1_ 0 15k
Q4144 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4144-Pad3_ 2SA1943
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
R4193 VMOUT Net-_Q4143-Pad3_ 0.33
XQ7011 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
L701 /POWER-AMP/VSAVN /POWER-AMP/VSFN 10uH
R713 /POWER-AMP/VSFN Net-_R713-Pad2_ 680
C704 /POWER-AMP/-120V /POWER-AMP/VSAVN 1uF
C703 /POWER-AMP/VSAVN Net-_R713-Pad2_ 2200pF
XQ7012 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
D709 /POWER-AMP/VSFN 0 MURF1560
R711 0 Net-_Q708-Pad2_ 15k
Q708 /POWER-AMP/VSGN Net-_Q708-Pad2_ Net-_Q708-Pad3_ 2N5551
R712 Net-_Q708-Pad3_ /POWER-AMP/-120V 27k
Q709 /POWER-AMP/VSGN Net-_Q708-Pad3_ /POWER-AMP/-120V 2N5551
D708 Net-_Q708-Pad2_ Net-_Q704-Pad1_ BAV21
D403 /POWER-AMP/VSAVN VMOUT MURF1560
C406 0 Net-_C406-Pad2_ 0.1uF
R613 /POWER-AMP/VSFP Net-_C603-Pad2_ 680
D609 0 /POWER-AMP/VSFP MURF1560
C603 /POWER-AMP/VSAVP Net-_C603-Pad2_ 2200pF
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
R420 VMOUT Net-_C406-Pad2_ 10
L401 VPOUT VMOUT 1uH
Q4146 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4146-Pad3_ 2SA1943
Q4145 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4145-Pad3_ 2SA1943
D402 VMOUT /POWER-AMP/VSAVP MURF1560
R607 Net-_R607-Pad1_ 0 15k
R609 /POWER-AMP/VSGZP 0 15k
.tran 0.1u 1m
.fourier 1k v(vmout)
.end
