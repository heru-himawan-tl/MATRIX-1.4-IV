.title MATRIX 1.4 IV T13 1400W RMS TD-CLASS - DEVELOPMENT RELEASE 1
.include "spice_models/model.lib"
V12 0 /POWER-AMP/-120V DC 120V
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
V32 0 /-15V DC 15V
V31 /+15V 0 DC 15V
Rdummy1 VPOUT 0 4
V11 /POWER-AMP/+120V 0 DC 120V
Q405 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q405-Pad3_ MJE340
R4081 Net-_Q405-Pad3_ /POWER-AMP/-120V 470
C410 0 /POWER-AMP/-120V 10uF
C409 /POWER-AMP/-120V 0 0.1uF
R4061 /POWER-AMP/+120V Net-_Q404-Pad3_ 56
Q403 Net-_Q402-Pad1_ Net-_Q402-Pad1_ Net-_Q403-Pad3_ MPSA92
Q404 Net-_C404-Pad1_ Net-_Q402-Pad1_ Net-_Q404-Pad3_ MPSA92
R4062 /POWER-AMP/+120V Net-_Q404-Pad3_ 470
R4051 /POWER-AMP/+120V Net-_Q403-Pad3_ 56
C407 0 /POWER-AMP/+120V 0.1uF
C408 /POWER-AMP/+120V 0 10uF
R4151 DRVN1 DRVP1 120
C405 VASN VASP 0.1uF
Q410 /POWER-AMP/-120V VASN DRVN1 MJE15033
Q407 VASN Net-_Q407-Pad2_ VASP MJE350
R411 Net-_Q407-Pad2_ VASP 390
D401 /POWER-AMP/-120V Net-_D401-Pad2_ 1N4732
R4082 Net-_Q405-Pad3_ /POWER-AMP/-120V 47k
R4074 0 Net-_D401-Pad2_ 56k
R4072 0 Net-_D401-Pad2_ 56k
R4073 0 Net-_D401-Pad2_ 56k
R410 Net-_Q407-Pad2_ VASN 1.2k
R4071 0 Net-_D401-Pad2_ 56k
R401 Net-_C402-Pad2_ Net-_C401-Pad2_ 180
C401 MAIN_IN Net-_C401-Pad2_ 10uF
R4021 Net-_C402-Pad2_ 0 15k
C403 Net-_C403-Pad1_ 0 220uF
C402 0 Net-_C402-Pad2_ 220pF
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ MPSA42
R4022 Net-_C402-Pad2_ 0 270k
Q401 Net-_C404-Pad1_ Net-_C402-Pad2_ Net-_Q401-Pad3_ MPSA42
R4141 Net-_Q408-Pad3_ /POWER-AMP/-120V 470
R4142 Net-_Q408-Pad3_ /POWER-AMP/-120V 47k
Q408 VASN Net-_D401-Pad2_ Net-_Q408-Pad3_ MJE340
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
R4193 VMOUT Net-_Q4143-Pad3_ 0.33
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
Q707 VSGZN Net-_Q706-Pad3_ /POWER-AMP/-120V 2N5551
R712 Net-_D707-Pad1_ VSGSPN 1.5k
R707 VSTCN Net-_Q705-Pad2_ 150
C704 VSGSPN /POWER-AMP/-120V 47uF
Q706 VSGZN Net-_D706-Pad1_ Net-_Q706-Pad3_ 2N5551
D706 Net-_D706-Pad1_ VSTAN BAV21
D707 Net-_D707-Pad1_ VSTAN BAV21
Q705 VSTAN Net-_Q705-Pad2_ /POWER-AMP/-120V 2N5551
R709 /POWER-AMP/-120V Net-_Q706-Pad3_ 27k
C706 /POWER-AMP/-120V VSAVN 1uF
L701 VSAVN VSFN 10uH
D709 VSFN 0 MURF1560
R715 VSFN Net-_C705-Pad2_ 680
C705 VSAVN Net-_C705-Pad2_ 2200pF
XQ7012 VSFN VSGN /POWER-AMP/-120V IRF640
XQ7011 VSFN VSGN /POWER-AMP/-120V IRF640
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
R420 VMOUT Net-_C406-Pad2_ 10
C406 0 Net-_C406-Pad2_ 0.1uF
L401 VPOUT VMOUT 1uH
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
R711 Net-_Q708-Pad3_ VSGN 15
Q708 VSGSPN VSGZN Net-_Q708-Pad3_ 2N5551
Q709 VSGN Net-_D707-Pad1_ Net-_Q709-Pad3_ 2N5551
Q710 VSGN Net-_Q709-Pad3_ /POWER-AMP/-120V 2N5551
R713 Net-_Q709-Pad3_ /POWER-AMP/-120V 27k
Q4143 VSAVN DRVN2 Net-_Q4143-Pad3_ 2SA1943
Q4145 VSAVN DRVN2 Net-_Q4145-Pad3_ 2SA1943
Q4144 VSAVN DRVN2 Net-_Q4144-Pad3_ 2SA1943
R708 Net-_D706-Pad1_ VSGSPN 1.5k
R710 VSGZN VSGSPN 1.5k
D403 VSAVN VMOUT MURF1560
Q4146 VSAVN DRVN2 Net-_Q4146-Pad3_ 2SA1943
D602 VMOUT Net-_C601-Pad2_ 1N4007
D702 Net-_C701-Pad1_ VMOUT 1N4007
C701 Net-_C701-Pad1_ Net-_C701-Pad2_ 4.7uF
R703 0 Net-_C701-Pad1_ 120k
R701 Net-_D701-Pad2_ /POWER-AMP/-120V 12k
C702 /POWER-AMP/-120V Net-_C702-Pad2_ 22pF
Q701 0 Net-_C701-Pad1_ Net-_D703-Pad2_ 2N5551
D703 Net-_C702-Pad2_ Net-_D703-Pad2_ 1N4734
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R702 Net-_C701-Pad2_ Net-_C702-Pad2_ 120k
Q702 /POWER-AMP/-120V Net-_C702-Pad2_ Net-_Q702-Pad3_ MJE350
R706 VSTCN /POWER-AMP/-120V 1
C703 Net-_C703-Pad1_ /POWER-AMP/-120V 4.7uF
D708 /POWER-AMP/-120V Net-_C703-Pad1_ 1N4749
Q704 VSTCN Net-_Q703-Pad3_ VSAVN 2SA1943
Q711 Net-_Q711-Pad1_ Net-_C703-Pad1_ VSGSPN 2N5551
Q712 VSGSPN Net-_Q711-Pad1_ 0 MJE350
R714 0 Net-_C703-Pad1_ 100k
R417 DRVN2 VMOUT 5.6
R416 VMOUT DRVP2 5.6
Q412 VSAVN DRVN1 DRVN2 2SA1943
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
Q4141 VSAVN DRVN2 Net-_Q4141-Pad3_ 2SA1943
Q4142 VSAVN DRVN2 Net-_Q4142-Pad3_ 2SA1943
Q4132 VSAVP DRVP2 Net-_Q4132-Pad3_ 2SC5200
Q4131 VSAVP DRVP2 Net-_Q4131-Pad3_ 2SC5200
Q411 VSAVP DRVP1 DRVP2 2SC5200
Q703 /POWER-AMP/-120V Net-_Q702-Pad3_ Net-_Q703-Pad3_ MJE15033
D704 Net-_D704-Pad1_ /POWER-AMP/-120V MURF1560
D705 VSTCN Net-_D704-Pad1_ MURF1560
R705 VSAVN Net-_Q703-Pad3_ 56
R704 VSAVN Net-_Q702-Pad3_ 1.5k
C604 /POWER-AMP/+120V VSGSPP 47uF
D606 VSTAP Net-_D606-Pad2_ BAV21
Q605 VSTAP Net-_Q605-Pad2_ /POWER-AMP/+120V 2N5401
R607 VSTCP Net-_Q605-Pad2_ 150
R609 /POWER-AMP/+120V Net-_Q606-Pad3_ 27k
R613 /POWER-AMP/+120V Net-_Q609-Pad3_ 27k
D607 VSTAP Net-_D607-Pad2_ BAV21
Q609 VSGP Net-_D607-Pad2_ Net-_Q609-Pad3_ 2N5401
Q607 VSGZP Net-_Q606-Pad3_ /POWER-AMP/+120V 2N5401
R612 Net-_D607-Pad2_ VSGSPP 1.5k
Q608 VSGSPP VSGZP Net-_Q608-Pad3_ MJE350
R611 VSGP Net-_Q608-Pad3_ 15
Q610 VSGP Net-_Q609-Pad3_ /POWER-AMP/+120V 2N5401
Q4133 VSAVP DRVP2 Net-_Q4133-Pad3_ 2SC5200
R608 Net-_D606-Pad2_ VSGSPP 1.5k
Q4134 VSAVP DRVP2 Net-_Q4134-Pad3_ 2SC5200
C605 VSAVP Net-_C605-Pad2_ 2200pF
XQ6012 VSFP VSGP /POWER-AMP/+120V IRF9640
XQ6011 VSFP VSGP /POWER-AMP/+120V IRF9640
R615 VSFP Net-_C605-Pad2_ 680
L601 VSAVP VSFP 10uH
D609 0 VSFP MURF1560
C606 VSAVP /POWER-AMP/+120V 1uF
D402 VMOUT VSAVP MURF1560
R610 VSGZP VSGSPP 1.5k
Q4135 VSAVP DRVP2 Net-_Q4135-Pad3_ 2SC5200
Q4136 VSAVP DRVP2 Net-_Q4136-Pad3_ 2SC5200
Q606 VSGZP Net-_D606-Pad2_ Net-_Q606-Pad3_ 2N5401
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
R601 /POWER-AMP/+120V Net-_D601-Pad1_ 12k
C602 Net-_C602-Pad1_ /POWER-AMP/+120V 22pF
Q602 /POWER-AMP/+120V Net-_C602-Pad1_ Net-_Q602-Pad3_ MJE340
D603 Net-_D603-Pad1_ Net-_C602-Pad1_ 1N4734
R602 Net-_C601-Pad1_ Net-_C602-Pad1_ 120k
C601 Net-_C601-Pad1_ Net-_C601-Pad2_ 4.7uF
R614 Net-_C603-Pad2_ 0 100k
Q611 Net-_Q611-Pad1_ Net-_C603-Pad2_ VSGSPP 2N5401
Q612 VSGSPP Net-_Q611-Pad1_ 0 MJE340
Q604 VSTCP Net-_Q603-Pad3_ VSAVP 2SC5200
D604 /POWER-AMP/+120V Net-_D604-Pad2_ MURF1560
D605 Net-_D604-Pad2_ VSTCP MURF1560
Q603 /POWER-AMP/+120V Net-_Q602-Pad3_ Net-_Q603-Pad3_ MJE15032
C603 /POWER-AMP/+120V Net-_C603-Pad2_ 4.7uF
D608 Net-_C603-Pad2_ /POWER-AMP/+120V 1N4749
R606 /POWER-AMP/+120V VSTCP 1
R603 Net-_C601-Pad2_ 0 120k
R605 Net-_Q603-Pad3_ VSAVP 56
Q601 0 Net-_C601-Pad2_ Net-_D603-Pad1_ 2N5401
R604 Net-_Q602-Pad3_ VSAVP 1.5k
R4052 /POWER-AMP/+120V Net-_Q403-Pad3_ 470
R4091 /POWER-AMP/+120V Net-_Q406-Pad3_ 150
R4092 /POWER-AMP/+120V Net-_Q406-Pad3_ 820
Q406 VASP Net-_C404-Pad1_ Net-_Q406-Pad3_ MJE350
C404 Net-_C404-Pad1_ VASP 220pF
R413 VASP Net-_R412-Pad1_ 2.2k
R404 Net-_Q402-Pad2_ Net-_C403-Pad1_ 180
RT401 VASP Net-_R412-Pad1_ 5k
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 390
R4031 VMOUT Net-_Q402-Pad2_ 15k
R4032 VMOUT Net-_Q402-Pad2_ 270k
Q409 /POWER-AMP/+120V VASP DRVP1 MJE15032
.end
