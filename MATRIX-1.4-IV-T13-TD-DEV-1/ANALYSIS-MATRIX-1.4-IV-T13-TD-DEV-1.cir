.title MATRIX 1.4 IV T13 1400W RMS TD-CLASS - DEVELOPMENT RELEASE 1
.include "spice_models/model.lib"
V12 0 /POWER-AMP/-120V 120V DC
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
V32 0 /-15V 15V DC
V31 /+15V 0 15V DC
Rdummy1 VPOUT 0 4
V11 /POWER-AMP/+120V 0 120V DC
D602 VMOUT Net-_D602-Pad2_ 1N4007
C601 Net-_C601-Pad1_ VMOUT 10uF
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
R603 Net-_D602-Pad2_ 0 12k
R601 /POWER-AMP/+120V Net-_D601-Pad1_ 1.5k
D702 Net-_D702-Pad1_ VMOUT 1N4007
R703 0 Net-_D702-Pad1_ 12k
R701 Net-_D701-Pad2_ /POWER-AMP/-120V 1.5k
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
C701 VMOUT Net-_C701-Pad2_ 10uF
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
R416 VMOUT /POWER-AMP/DRVP2 5.6
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
R417 /POWER-AMP/DRVN2 VMOUT 5.6
R420 VMOUT Net-_C406-Pad2_ 10
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
Q4136 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4136-Pad3_ 2SC5200
Q4135 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4135-Pad3_ 2SC5200
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
L401 VPOUT VMOUT 1uH
D402 VMOUT /POWER-AMP/VSAVP MURF1560
R613 /POWER-AMP/VSFP Net-_C603-Pad1_ 680
L601 /POWER-AMP/VSAVP /POWER-AMP/VSFP 10uH
C603 Net-_C603-Pad1_ /POWER-AMP/VSAVP 2200pF
C604 /POWER-AMP/VSAVP /POWER-AMP/+120V 1uF
XQ6012 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
XQ6011 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
D609 0 /POWER-AMP/VSFP MURF1560
Q604 /POWER-AMP/VSTCP Net-_Q603-Pad3_ /POWER-AMP/VSAVP 2SC5200
Q602 /POWER-AMP/+120V Net-_C602-Pad1_ Net-_Q602-Pad3_ MJE340
C602 Net-_C602-Pad1_ /POWER-AMP/+120V 330pF
D605 Net-_D604-Pad2_ /POWER-AMP/VSTCP MURF1560
D604 /POWER-AMP/+120V Net-_D604-Pad2_ MURF1560
Q603 /POWER-AMP/+120V Net-_Q602-Pad3_ Net-_Q603-Pad3_ MJE15032
R602 Net-_C601-Pad1_ Net-_C602-Pad1_ 12k
Q601 0 Net-_D602-Pad2_ Net-_D603-Pad1_ 2N5401
D603 Net-_D603-Pad1_ Net-_C602-Pad1_ 1N4734
R607 /POWER-AMP/+120V /POWER-AMP/VSTCP 1
R608 /POWER-AMP/VSTCP Net-_Q605-Pad2_ 150
R612 /POWER-AMP/VSGP Net-_Q606-Pad1_ 560
Q607 Net-_D607-Pad1_ Net-_D606-Pad2_ Net-_Q607-Pad3_ 2N5401
D607 Net-_D607-Pad1_ /POWER-AMP/VSGP BAV21
R610 Net-_Q606-Pad2_ 0 1.5k
R611 Net-_D606-Pad2_ 0 15k
Q606 Net-_Q606-Pad1_ Net-_Q606-Pad2_ 0 MJE340
Q605 Net-_D606-Pad1_ Net-_Q605-Pad2_ /POWER-AMP/+120V 2N5401
D606 Net-_D606-Pad1_ Net-_D606-Pad2_ BAV21
R609 Net-_D606-Pad1_ Net-_Q606-Pad2_ 1.5k
Q608 /POWER-AMP/VSGP Net-_Q607-Pad3_ /POWER-AMP/+120V 2N5401
D608 /POWER-AMP/VSGP /POWER-AMP/+120V 1N4742
Q4132 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4132-Pad3_ 2SC5200
Q4131 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4131-Pad3_ 2SC5200
Q4134 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4134-Pad3_ 2SC5200
Q4133 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4133-Pad3_ 2SC5200
R606 Net-_Q603-Pad3_ /POWER-AMP/VSAVP 56
R605 Net-_Q602-Pad3_ /POWER-AMP/VSAVP 1.5k
R604 Net-_C602-Pad1_ /POWER-AMP/VSAVP 2.7k
Q411 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 /POWER-AMP/DRVP2 2SC5200
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
R4193 VMOUT Net-_Q4143-Pad3_ 0.33
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
Q4144 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4144-Pad3_ 2SA1943
Q4143 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4143-Pad3_ 2SA1943
D706 Net-_D706-Pad1_ Net-_D706-Pad2_ BAV21
Q705 Net-_D706-Pad2_ Net-_Q705-Pad2_ /POWER-AMP/-120V 2N5551
Q707 Net-_D707-Pad2_ Net-_D706-Pad1_ Net-_Q707-Pad3_ 2N5551
R709 Net-_D706-Pad2_ Net-_Q706-Pad2_ 1.5k
XQ7012 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
L701 /POWER-AMP/VSAVN /POWER-AMP/VSFN 10uH
XQ7011 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
C703 /POWER-AMP/VSAVN Net-_C703-Pad2_ 2200pF
C704 /POWER-AMP/-120V /POWER-AMP/VSAVN 1uF
D709 /POWER-AMP/VSFN 0 MURF1560
R713 Net-_C703-Pad2_ /POWER-AMP/VSFN 680
R702 Net-_C701-Pad2_ Net-_C702-Pad2_ 12k
C702 /POWER-AMP/-120V Net-_C702-Pad2_ 330pF
Q701 0 Net-_D702-Pad1_ Net-_D703-Pad2_ 2N5551
D703 Net-_C702-Pad2_ Net-_D703-Pad2_ 1N4734
Q702 /POWER-AMP/-120V Net-_C702-Pad2_ Net-_Q702-Pad3_ MJE350
R710 Net-_Q706-Pad2_ 0 1.5k
R711 Net-_D706-Pad1_ 0 15k
Q706 Net-_Q706-Pad1_ Net-_Q706-Pad2_ 0 MJE350
Q4146 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4146-Pad3_ 2SA1943
Q4145 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4145-Pad3_ 2SA1943
C406 0 Net-_C406-Pad2_ 0.1uF
D403 /POWER-AMP/VSAVN VMOUT MURF1560
D704 Net-_D704-Pad1_ /POWER-AMP/-120V MURF1560
R707 /POWER-AMP/VSTCN /POWER-AMP/-120V 1
D705 /POWER-AMP/VSTCN Net-_D704-Pad1_ MURF1560
R708 /POWER-AMP/VSTCN Net-_Q705-Pad2_ 150
Q704 /POWER-AMP/VSTCN Net-_Q703-Pad3_ /POWER-AMP/VSAVN 2SA1943
Q703 /POWER-AMP/-120V Net-_Q702-Pad3_ Net-_Q703-Pad3_ MJE15033
Q412 /POWER-AMP/VSAVN /POWER-AMP/DRVN1 /POWER-AMP/DRVN2 2SA1943
R704 /POWER-AMP/VSAVN Net-_C702-Pad2_ 2.7k
R706 /POWER-AMP/VSAVN Net-_Q703-Pad3_ 56
R705 /POWER-AMP/VSAVN Net-_Q702-Pad3_ 1.5k
Q4141 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4141-Pad3_ 2SA1943
Q4142 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4142-Pad3_ 2SA1943
R712 Net-_Q706-Pad1_ /POWER-AMP/VSGN 560
D707 /POWER-AMP/VSGN Net-_D707-Pad2_ BAV21
D708 /POWER-AMP/-120V /POWER-AMP/VSGN 1N4742
Q708 /POWER-AMP/VSGN Net-_Q707-Pad3_ /POWER-AMP/-120V 2N5551
R410 Net-_Q407-Pad2_ /POWER-AMP/VASN 1.2k
R4151 /POWER-AMP/DRVN1 /POWER-AMP/DRVP1 120
Q410 /POWER-AMP/-120V /POWER-AMP/VASN /POWER-AMP/DRVN1 MJE15033
R4142 Net-_Q408-Pad3_ /POWER-AMP/-120V 47k
Q408 /POWER-AMP/VASN Net-_D401-Pad2_ Net-_Q408-Pad3_ MJE340
R4141 Net-_Q408-Pad3_ /POWER-AMP/-120V 470
D401 /POWER-AMP/-120V Net-_D401-Pad2_ 1N4732
Q407 /POWER-AMP/VASN Net-_Q407-Pad2_ /POWER-AMP/VASP MJE350
C405 /POWER-AMP/VASN /POWER-AMP/VASP 0.1uF
R411 Net-_Q407-Pad2_ /POWER-AMP/VASP 390
R413 /POWER-AMP/VASP Net-_R412-Pad1_ 2.2k
RT401 /POWER-AMP/VASP Net-_R412-Pad1_ 5k
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 390
R4081 Net-_Q405-Pad3_ /POWER-AMP/-120V 470
C409 /POWER-AMP/-120V 0 0.1uF
R4082 Net-_Q405-Pad3_ /POWER-AMP/-120V 47k
C410 0 /POWER-AMP/-120V 10uF
Q405 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q405-Pad3_ MJE340
R4021 Net-_C402-Pad2_ 0 15k
Q401 Net-_C404-Pad1_ Net-_C402-Pad2_ Net-_Q401-Pad3_ MPSA42
R4022 Net-_C402-Pad2_ 0 270k
R4031 VMOUT Net-_Q402-Pad2_ 15k
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ MPSA42
R4032 VMOUT Net-_Q402-Pad2_ 270k
C402 0 Net-_C402-Pad2_ 220pF
R4074 0 Net-_D401-Pad2_ 56k
R4073 0 Net-_D401-Pad2_ 56k
R4072 0 Net-_D401-Pad2_ 56k
R4071 0 Net-_D401-Pad2_ 56k
R401 Net-_C402-Pad2_ Net-_C401-Pad2_ 180
C401 MAIN_IN Net-_C401-Pad2_ 10uF
R404 Net-_Q402-Pad2_ Net-_C403-Pad1_ 180
C403 Net-_C403-Pad1_ 0 220uF
C408 /POWER-AMP/+120V 0 10uF
R4062 /POWER-AMP/+120V Net-_Q404-Pad3_ 470
R4061 /POWER-AMP/+120V Net-_Q404-Pad3_ 56
C407 0 /POWER-AMP/+120V 0.1uF
R4092 /POWER-AMP/+120V /POWER-AMP/VASDEP 820
Q406 /POWER-AMP/VASP Net-_C404-Pad1_ /POWER-AMP/VASDEP MJE350
R4091 /POWER-AMP/+120V /POWER-AMP/VASDEP 150
C404 Net-_C404-Pad1_ /POWER-AMP/VASP 220pF
Q409 /POWER-AMP/+120V /POWER-AMP/VASP /POWER-AMP/DRVP1 MJE15032
Q403 Net-_Q402-Pad1_ Net-_Q402-Pad1_ Net-_Q403-Pad3_ MPSA92
R4051 /POWER-AMP/+120V Net-_Q403-Pad3_ 56
R4052 /POWER-AMP/+120V Net-_Q403-Pad3_ 470
Q404 Net-_C404-Pad1_ Net-_Q402-Pad1_ Net-_Q404-Pad3_ MPSA92
.end
