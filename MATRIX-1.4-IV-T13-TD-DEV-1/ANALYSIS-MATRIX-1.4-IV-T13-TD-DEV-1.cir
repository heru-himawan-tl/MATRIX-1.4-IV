.title MATRIX 1.4 IV T13 1400W RMS TD-CLASS - DEVELOPMENT RELEASE 1
.include "spice_models/model.lib"
V12 0 /POWER-AMP/-120V DC 120V
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
V32 0 /-15V DC 15V
V31 /+15V 0 DC 15V
Rdummy1 VPOUT 0 4
V11 /POWER-AMP/+120V 0 DC 120V
Q4132 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4132-Pad3_ 2SC5200
Q4131 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4131-Pad3_ 2SC5200
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
R416 VMOUT /POWER-AMP/DRVP2 5.6
Q411 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 /POWER-AMP/DRVP2 2SC5200
Q611 Net-_Q611-Pad1_ Net-_D608-Pad1_ /POWER-AMP/VSGSPP 2N5401
Q612 /POWER-AMP/VSGSPP Net-_Q611-Pad1_ 0 MJE340
D606 /POWER-AMP/VSTAP Net-_Q606-Pad2_ BAV21
R609 /POWER-AMP/+120V Net-_Q606-Pad3_ 27k
Q605 /POWER-AMP/VSTAP Net-_Q605-Pad2_ /POWER-AMP/+120V 2N5401
Q606 /POWER-AMP/VSGZP Net-_Q606-Pad2_ Net-_Q606-Pad3_ 2N5401
Q4135 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4135-Pad3_ 2SC5200
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
Q4133 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4133-Pad3_ 2SC5200
Q4134 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4134-Pad3_ 2SC5200
Q610 /POWER-AMP/VSGP Net-_Q609-Pad3_ /POWER-AMP/+120V 2N5401
R613 /POWER-AMP/+120V Net-_Q609-Pad3_ 27k
D607 /POWER-AMP/VSTAP Net-_D607-Pad2_ BAV21
Q609 /POWER-AMP/VSGP Net-_D607-Pad2_ Net-_Q609-Pad3_ 2N5401
R612 Net-_D607-Pad2_ /POWER-AMP/VSGSPP 2.7k
Q608 /POWER-AMP/VSGSPP /POWER-AMP/VSGZP Net-_Q608-Pad3_ MJE350
R610 /POWER-AMP/VSGZP /POWER-AMP/VSGSPP 2.7k
R608 Net-_Q606-Pad2_ /POWER-AMP/VSGSPP 2.7k
R611 /POWER-AMP/VSGP Net-_Q608-Pad3_ 15
Q607 /POWER-AMP/VSGZP Net-_Q606-Pad3_ /POWER-AMP/+120V 2N5401
D605 Net-_D604-Pad2_ /POWER-AMP/VSTCP MURF1560
R606 /POWER-AMP/+120V /POWER-AMP/VSTCP 1
R614 Net-_D608-Pad1_ 0 100k
Q604 /POWER-AMP/VSTCP Net-_Q604-Pad2_ /POWER-AMP/VSAVP 2SC5200
D604 /POWER-AMP/+120V Net-_D604-Pad2_ MURF1560
C604 /POWER-AMP/+120V /POWER-AMP/VSGSPP 47uF
R607 /POWER-AMP/VSTCP Net-_Q605-Pad2_ 150
C603 /POWER-AMP/+120V Net-_D608-Pad1_ 4.7uF
D608 Net-_D608-Pad1_ /POWER-AMP/+120V 1N4749
D609 0 /POWER-AMP/VSFP MURF1560
C606 /POWER-AMP/VSAVP /POWER-AMP/+120V 1uF
L601 /POWER-AMP/VSAVP /POWER-AMP/VSFP 10uH
C605 /POWER-AMP/VSAVP Net-_C605-Pad2_ 2200pF
XQ6011 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
XQ6012 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
R615 /POWER-AMP/VSFP Net-_C605-Pad2_ 680
R704 /POWER-AMP/VSAVN Net-_R704-Pad2_ 1.5k
Q701 0 Net-_C701-Pad1_ Net-_D703-Pad2_ 2N5551
C702 /POWER-AMP/-120V Net-_C702-Pad2_ 12pF
D703 Net-_C702-Pad2_ Net-_D703-Pad2_ 1N4734
Q702 /POWER-AMP/-120V Net-_C702-Pad2_ Net-_R704-Pad2_ MJE350
R703 0 Net-_C701-Pad1_ 120k
Q703 /POWER-AMP/-120V Net-_R704-Pad2_ Net-_Q704-Pad2_ MJE15033
C409 /POWER-AMP/-120V 0 0.1uF
C410 0 /POWER-AMP/-120V 10uF
Q405 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q405-Pad3_ MJE340
R4081 Net-_Q405-Pad3_ /POWER-AMP/-120V 470
D401 /POWER-AMP/-120V Net-_D401-Pad2_ 1N4732
R4073 0 Net-_D401-Pad2_ 56k
R4072 0 Net-_D401-Pad2_ 56k
R4082 Net-_Q405-Pad3_ /POWER-AMP/-120V 47k
R4074 0 Net-_D401-Pad2_ 56k
R4071 0 Net-_D401-Pad2_ 56k
C405 /POWER-AMP/VASN /POWER-AMP/VASP 0.1uF
R411 Net-_Q407-Pad2_ /POWER-AMP/VASP 390
Q407 /POWER-AMP/VASN Net-_Q407-Pad2_ /POWER-AMP/VASP MJE350
R410 Net-_Q407-Pad2_ /POWER-AMP/VASN 1.2k
R4151 /POWER-AMP/DRVN1 /POWER-AMP/DRVP1 120
D702 Net-_C701-Pad1_ VMOUT 1N4007
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R701 Net-_D701-Pad2_ /POWER-AMP/-120V 12k
R4141 Net-_Q408-Pad3_ /POWER-AMP/-120V 470
Q408 /POWER-AMP/VASN Net-_D401-Pad2_ Net-_Q408-Pad3_ MJE340
R4142 Net-_Q408-Pad3_ /POWER-AMP/-120V 47k
R702 Net-_C701-Pad2_ Net-_C702-Pad2_ 120k
Q410 /POWER-AMP/-120V /POWER-AMP/VASN /POWER-AMP/DRVN1 MJE15033
C701 Net-_C701-Pad1_ Net-_C701-Pad2_ 4.7uF
R401 Net-_C402-Pad2_ Net-_C401-Pad2_ 180
C401 MAIN_IN Net-_C401-Pad2_ 10uF
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ MPSA42
Q401 Net-_C404-Pad1_ Net-_C402-Pad2_ Net-_Q401-Pad3_ MPSA42
C403 Net-_C403-Pad1_ 0 220uF
R4031 VMOUT Net-_Q402-Pad2_ 15k
R413 /POWER-AMP/VASP Net-_R412-Pad1_ 2.2k
RT401 /POWER-AMP/VASP Net-_R412-Pad1_ 5k
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 390
R604 Net-_Q602-Pad3_ /POWER-AMP/VSAVP 1.5k
D603 Net-_D603-Pad1_ Net-_C602-Pad1_ 1N4734
Q601 0 Net-_C601-Pad2_ Net-_D603-Pad1_ 2N5401
Q409 /POWER-AMP/+120V /POWER-AMP/VASP /POWER-AMP/DRVP1 MJE15032
R603 Net-_C601-Pad2_ 0 120k
D602 VMOUT Net-_C601-Pad2_ 1N4007
R605 Net-_Q604-Pad2_ /POWER-AMP/VSAVP 56
C601 Net-_C601-Pad1_ Net-_C601-Pad2_ 4.7uF
Q403 Net-_Q402-Pad1_ Net-_Q402-Pad1_ Net-_Q403-Pad3_ MPSA92
C408 /POWER-AMP/+120V 0 10uF
R4062 /POWER-AMP/+120V Net-_Q404-Pad3_ 470
R4061 /POWER-AMP/+120V Net-_Q404-Pad3_ 56
C407 0 /POWER-AMP/+120V 0.1uF
R4051 /POWER-AMP/+120V Net-_Q403-Pad3_ 56
Q404 Net-_C404-Pad1_ Net-_Q402-Pad1_ Net-_Q404-Pad3_ MPSA92
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
R601 /POWER-AMP/+120V Net-_D601-Pad1_ 12k
C602 Net-_C602-Pad1_ /POWER-AMP/+120V 12pF
Q602 /POWER-AMP/+120V Net-_C602-Pad1_ Net-_Q602-Pad3_ MJE340
R602 Net-_C601-Pad1_ Net-_C602-Pad1_ 120k
Q603 /POWER-AMP/+120V Net-_Q602-Pad3_ Net-_Q604-Pad2_ MJE15032
C404 Net-_C404-Pad1_ /POWER-AMP/VASP 220pF
R4032 VMOUT Net-_Q402-Pad2_ 270k
R404 Net-_Q402-Pad2_ Net-_C403-Pad1_ 180
R4091 /POWER-AMP/+120V /POWER-AMP/VASDEP 150
Q406 /POWER-AMP/VASP Net-_C404-Pad1_ /POWER-AMP/VASDEP MJE350
R4092 /POWER-AMP/+120V /POWER-AMP/VASDEP 820
R4052 /POWER-AMP/+120V Net-_Q403-Pad3_ 470
R4022 Net-_C402-Pad2_ 0 270k
R4021 Net-_C402-Pad2_ 0 15k
C402 0 Net-_C402-Pad2_ 220pF
Q704 /POWER-AMP/VSTCN Net-_Q704-Pad2_ /POWER-AMP/VSAVN 2SA1943
D704 Net-_D704-Pad1_ /POWER-AMP/-120V MURF1560
R705 /POWER-AMP/VSAVN Net-_Q704-Pad2_ 56
D705 /POWER-AMP/VSTCN Net-_D704-Pad1_ MURF1560
R706 /POWER-AMP/VSTCN /POWER-AMP/-120V 1
D709 /POWER-AMP/VSFN 0 MURF1560
R715 /POWER-AMP/VSFN Net-_C705-Pad2_ 680
L701 /POWER-AMP/VSAVN /POWER-AMP/VSFN 10uH
Q710 /POWER-AMP/VSGN Net-_Q709-Pad3_ /POWER-AMP/-120V 2N5551
XQ7012 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
C706 /POWER-AMP/-120V /POWER-AMP/VSAVN 1uF
XQ7011 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
Q708 /POWER-AMP/VSGSPN /POWER-AMP/VSGZN Net-_Q708-Pad3_ 2N5551
R711 Net-_Q708-Pad3_ /POWER-AMP/VSGN 15
C705 /POWER-AMP/VSAVN Net-_C705-Pad2_ 2200pF
Q712 /POWER-AMP/VSGSPN Net-_Q711-Pad1_ 0 MJE350
R709 /POWER-AMP/-120V Net-_Q706-Pad3_ 27k
Q705 /POWER-AMP/VSTAN Net-_R707-Pad2_ /POWER-AMP/-120V 2N5551
R710 /POWER-AMP/VSGZN /POWER-AMP/VSGSPN 2.7k
R713 Net-_Q709-Pad3_ /POWER-AMP/-120V 27k
Q709 /POWER-AMP/VSGN Net-_D707-Pad1_ Net-_Q709-Pad3_ 2N5551
D706 Net-_D706-Pad1_ /POWER-AMP/VSTAN BAV21
Q706 /POWER-AMP/VSGZN Net-_D706-Pad1_ Net-_Q706-Pad3_ 2N5551
R708 Net-_D706-Pad1_ /POWER-AMP/VSGSPN 2.7k
D707 Net-_D707-Pad1_ /POWER-AMP/VSTAN BAV21
Q707 /POWER-AMP/VSGZN Net-_Q706-Pad3_ /POWER-AMP/-120V 2N5551
R712 Net-_D707-Pad1_ /POWER-AMP/VSGSPN 2.7k
C704 /POWER-AMP/VSGSPN /POWER-AMP/-120V 47uF
D708 /POWER-AMP/-120V Net-_Q711-Pad2_ 1N4749
C703 Net-_Q711-Pad2_ /POWER-AMP/-120V 4.7uF
R714 0 Net-_Q711-Pad2_ 100k
Q711 Net-_Q711-Pad1_ Net-_Q711-Pad2_ /POWER-AMP/VSGSPN 2N5551
R707 /POWER-AMP/VSTCN Net-_R707-Pad2_ 150
Q4143 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4143-Pad3_ 2SA1943
R4193 VMOUT Net-_Q4143-Pad3_ 0.33
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
Q4144 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4144-Pad3_ 2SA1943
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
R417 /POWER-AMP/DRVN2 VMOUT 5.6
Q4141 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4141-Pad3_ 2SA1943
Q412 /POWER-AMP/VSAVN /POWER-AMP/DRVN1 /POWER-AMP/DRVN2 2SA1943
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
Q4146 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4146-Pad3_ 2SA1943
Q4145 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4145-Pad3_ 2SA1943
R420 VMOUT Net-_C406-Pad2_ 10
C406 0 Net-_C406-Pad2_ 0.1uF
D403 /POWER-AMP/VSAVN VMOUT MURF1560
Q4142 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4142-Pad3_ 2SA1943
Q4136 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4136-Pad3_ 2SC5200
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
D402 VMOUT /POWER-AMP/VSAVP MURF1560
L401 VPOUT VMOUT 1uH
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
.end
