.title MATRIX 1.4 IV T13 1400W RMS TD-CLASS - DEVELOPMENT RELEASE 1
.include "spice_models/model.lib"
V12 0 /POWER-AMP/-120V 120V DC
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
V32 0 /-15V 15V DC
V31 /+15V 0 15V DC
Rdummy1 P_OUTPUT 0 4
V11 /POWER-AMP/+120V 0 120V DC
Q41510 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q41510-Pad3_ 2SA1943
Q41410 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q41410-Pad3_ 2SC5200
R4228 V_OUT_INT Net-_Q4158-Pad3_ 0.56
R4229 V_OUT_INT Net-_Q4159-Pad3_ 0.56
R4218 Net-_Q4148-Pad3_ V_OUT_INT 0.56
R4219 Net-_Q4149-Pad3_ V_OUT_INT 0.56
Q4159 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4159-Pad3_ 2SA1943
Q4158 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4158-Pad3_ 2SA1943
R42210 V_OUT_INT Net-_Q41510-Pad3_ 0.56
R42110 Net-_Q41410-Pad3_ V_OUT_INT 0.56
Q4148 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q4148-Pad3_ 2SC5200
Q4149 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q4149-Pad3_ 2SC5200
D709 /POWER-AMP/-120V /POWER-AMP/VSGN 1N4742
XQ7011 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
D612 0 /POWER-AMP/VSAVP MURF1560
D611 /POWER-AMP/VSFP /POWER-AMP/+120V MURF1560
L601 /POWER-AMP/VSAVP /POWER-AMP/VSFP 10uH
D613 /POWER-AMP/VSAVP /POWER-AMP/+120V MURF1560
C602 /POWER-AMP/+120V /POWER-AMP/VSAVP 4.7uF
D711 /POWER-AMP/-120V /POWER-AMP/VSFN MURF1560
L701 /POWER-AMP/VSAVN /POWER-AMP/VSFN 10uF
D712 /POWER-AMP/VSAVN 0 MURF1560
C702 /POWER-AMP/VSAVN /POWER-AMP/-120V 4.7uF
D713 /POWER-AMP/-120V /POWER-AMP/VSAVN MURF1560
XQ7012 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
D710 /POWER-AMP/VSFN 0 MURF1560
R423 V_OUT_INT Net-_C407-Pad2_ 10
D411 V_OUT_INT /POWER-AMP/VSAVP MURF1560
L401 P_OUTPUT V_OUT_INT 1uH
D412 /POWER-AMP/VSAVN V_OUT_INT MURF1560
C407 0 Net-_C407-Pad2_ 0.1uF
D610 0 /POWER-AMP/VSFP MURF1560
XQ6012 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
D609 /POWER-AMP/VSGP /POWER-AMP/+120V 1N4742
XQ6011 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
D708 Net-_D708-Pad1_ Net-_D708-Pad2_ 1N4148
Q704 Net-_D708-Pad2_ Net-_Q704-Pad2_ /POWER-AMP/-120V 2N5551
R709 Net-_D708-Pad1_ 0 15k
Q706 Net-_Q706-Pad1_ Net-_Q705-Pad1_ 0 2N5401
R710 Net-_Q706-Pad1_ /POWER-AMP/VSGN 27
Q707 /POWER-AMP/VSGN Net-_D708-Pad1_ Net-_Q707-Pad3_ 2N5551
Q708 /POWER-AMP/VSGN Net-_Q707-Pad3_ /POWER-AMP/-120V 2N5551
Q705 Net-_Q705-Pad1_ Net-_Q705-Pad1_ 0 2N5401
R708 Net-_D708-Pad2_ Net-_Q705-Pad1_ 1.5k
Q703 /POWER-AMP/VSTCN Net-_Q702-Pad3_ /POWER-AMP/VSAVN 2SA1943
R705 /POWER-AMP/VSAVN Net-_Q702-Pad3_ 56
D603 Net-_D602-Pad1_ Net-_D603-Pad2_ 1N4007
D604 V_OUT_INT Net-_D603-Pad2_ 1N4736
C601 Net-_C601-Pad1_ V_OUT_INT 10uF
Q601 /POWER-AMP/+120V Net-_D602-Pad2_ Net-_Q601-Pad3_ MJE340
D605 Net-_D602-Pad2_ /POWER-AMP/+120V 1N4007
R602 Net-_C601-Pad1_ Net-_D602-Pad1_ 12k
D602 Net-_D602-Pad1_ Net-_D602-Pad2_ 1N4007
R601 /POWER-AMP/+120V Net-_D601-Pad1_ 1.5k
R603 Net-_D602-Pad2_ /POWER-AMP/VSAVP 2.7k
R604 Net-_Q601-Pad3_ /POWER-AMP/VSAVP 1.5k
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
R704 /POWER-AMP/VSAVN Net-_Q701-Pad3_ 1.5k
Q413 /POWER-AMP/VSAVN /POWER-AMP/DRVN1 /POWER-AMP/DRVN2 2SA1943
R703 /POWER-AMP/VSAVN Net-_D703-Pad1_ 2.7k
D704 Net-_D702-Pad1_ V_OUT_INT 1N4736
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R701 Net-_D701-Pad2_ /POWER-AMP/-120V 1.5k
C701 V_OUT_INT Net-_C701-Pad2_ 10uF
D702 Net-_D702-Pad1_ Net-_D702-Pad2_ 1N4007
D703 Net-_D703-Pad1_ Net-_D702-Pad2_ 1N4007
R702 Net-_C701-Pad2_ Net-_D702-Pad2_ 12k
D707 /POWER-AMP/VSTCN Net-_D706-Pad1_ MURF1560
D706 Net-_D706-Pad1_ /POWER-AMP/-120V MURF1560
R706 /POWER-AMP/VSTCN /POWER-AMP/-120V 1
R707 /POWER-AMP/VSTCN Net-_Q704-Pad2_ 150
Q702 /POWER-AMP/-120V Net-_Q701-Pad3_ Net-_Q702-Pad3_ MJE15033
Q701 /POWER-AMP/-120V Net-_D703-Pad1_ Net-_Q701-Pad3_ MJE350
D705 /POWER-AMP/-120V Net-_D703-Pad1_ 1N4007
Q412 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 /POWER-AMP/DRVP1 2SC5200
R420 /POWER-AMP/DRVN2 V_OUT_INT 5.6
R419 V_OUT_INT /POWER-AMP/DRVP1 5.6
Q4142 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q4142-Pad3_ 2SC5200
R4211 Net-_Q4141-Pad3_ V_OUT_INT 0.56
R4221 V_OUT_INT Net-_Q4151-Pad3_ 0.56
Q4143 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q4143-Pad3_ 2SC5200
Q4151 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4151-Pad3_ 2SA1943
Q4152 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4152-Pad3_ 2SA1943
R4212 Net-_Q4142-Pad3_ V_OUT_INT 0.56
R4222 V_OUT_INT Net-_Q4152-Pad3_ 0.56
Q4141 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q4141-Pad3_ 2SC5200
Q4153 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4153-Pad3_ 2SA1943
R605 Net-_Q602-Pad3_ /POWER-AMP/VSAVP 56
Q603 /POWER-AMP/VSTCP Net-_Q602-Pad3_ /POWER-AMP/VSAVP 2SC5200
R607 /POWER-AMP/VSTCP Net-_Q604-Pad2_ 150
D607 Net-_D606-Pad2_ /POWER-AMP/VSTCP MURF1560
Q602 /POWER-AMP/+120V Net-_Q601-Pad3_ Net-_Q602-Pad3_ MJE15032
R606 /POWER-AMP/+120V /POWER-AMP/VSTCP 1
D606 /POWER-AMP/+120V Net-_D606-Pad2_ MURF1560
Q604 Net-_D608-Pad1_ Net-_Q604-Pad2_ /POWER-AMP/+120V 2N5401
R608 Net-_D608-Pad1_ Net-_Q605-Pad1_ 1.5k
Q605 Net-_Q605-Pad1_ Net-_Q605-Pad1_ 0 2N5551
Q4144 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q4144-Pad3_ 2SC5200
Q4145 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q4145-Pad3_ 2SC5200
R610 /POWER-AMP/VSGP Net-_Q606-Pad1_ 27
Q608 /POWER-AMP/VSGP Net-_Q607-Pad3_ /POWER-AMP/+120V 2N5401
D608 Net-_D608-Pad1_ Net-_D608-Pad2_ 1N4148
Q607 /POWER-AMP/VSGP Net-_D608-Pad2_ Net-_Q607-Pad3_ 2N5401
Q606 Net-_Q606-Pad1_ Net-_Q605-Pad1_ 0 2N5551
R609 Net-_D608-Pad2_ 0 15k
Q4146 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q4146-Pad3_ 2SC5200
Q4147 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 Net-_Q4147-Pad3_ 2SC5200
Q4157 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4157-Pad3_ 2SA1943
R4216 Net-_Q4146-Pad3_ V_OUT_INT 0.56
R4226 V_OUT_INT Net-_Q4156-Pad3_ 0.56
R4217 Net-_Q4147-Pad3_ V_OUT_INT 0.56
R4227 V_OUT_INT Net-_Q4157-Pad3_ 0.56
R4223 V_OUT_INT Net-_Q4153-Pad3_ 0.56
R4224 V_OUT_INT Net-_Q4154-Pad3_ 0.56
Q4154 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4154-Pad3_ 2SA1943
R4213 Net-_Q4143-Pad3_ V_OUT_INT 0.56
Q4156 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4156-Pad3_ 2SA1943
Q4155 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4155-Pad3_ 2SA1943
R4214 Net-_Q4144-Pad3_ V_OUT_INT 0.56
R4215 Net-_Q4145-Pad3_ V_OUT_INT 0.56
R4225 V_OUT_INT Net-_Q4155-Pad3_ 0.56
Q402 Net-_C404-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ 2N5551
C404 Net-_C404-Pad1_ /POWER-AMP/VASDIFF 100pF
Q405 /POWER-AMP/VASDIFF Net-_C404-Pad1_ Net-_Q405-Pad3_ MJE350
Q401 Net-_C403-Pad1_ Net-_Q401-Pad2_ Net-_Q401-Pad3_ 2N5551
C401 MAIN_IN Net-_C401-Pad2_ 10uF
R401 Net-_C401-Pad2_ Net-_Q401-Pad2_ 180
RT402 /POWER-AMP/VASP Net-_R415-Pad1_ 5k
C406 Net-_C406-Pad1_ /POWER-AMP/VASN 100pF
Q411 /POWER-AMP/-120V /POWER-AMP/VASN /POWER-AMP/DRVN1 MJE15033
Q406 Net-_C406-Pad1_ 0 /POWER-AMP/VASDIFF MJE350
R4082 Net-_Q403-Pad3_ /POWER-AMP/-120V 47k
R4111 Net-_Q407-Pad3_ /POWER-AMP/-120V 150
R4172 Net-_Q409-Pad3_ /POWER-AMP/-120V 820
Q409 /POWER-AMP/VASN Net-_C406-Pad1_ Net-_Q409-Pad3_ MJE340
Q407 Net-_C406-Pad1_ Net-_C406-Pad1_ Net-_Q407-Pad3_ MJE340
R4171 Net-_Q409-Pad3_ /POWER-AMP/-120V 150
R4112 Net-_Q407-Pad3_ /POWER-AMP/-120V 820
R4073 0 Net-_D401-Pad2_ 56k
R4021 Net-_Q401-Pad2_ 0 15k
R4071 0 Net-_D401-Pad2_ 56k
R4072 0 Net-_D401-Pad2_ 56k
R4022 Net-_Q401-Pad2_ 0 270k
R4032 V_OUT_INT Net-_Q402-Pad2_ 270k
R4031 V_OUT_INT Net-_Q402-Pad2_ 15k
Q410 /POWER-AMP/+120V /POWER-AMP/VASP /POWER-AMP/DRVP1 MJE15032
C402 Net-_C402-Pad1_ 0 220uF
R404 Net-_C402-Pad1_ Net-_Q402-Pad2_ 180
C405 /POWER-AMP/VASN /POWER-AMP/VASP 0.1uF
R413 Net-_Q408-Pad2_ /POWER-AMP/VASN 1.2k
Q408 /POWER-AMP/VASN Net-_Q408-Pad2_ /POWER-AMP/VASP MJE350
R415 Net-_R415-Pad1_ Net-_Q408-Pad2_ 390
R414 Net-_Q408-Pad2_ /POWER-AMP/VASP 390
R4181 /POWER-AMP/DRVN1 /POWER-AMP/DRVP1 120
R416 /POWER-AMP/VASP Net-_R415-Pad1_ 2.2k
R4121 /POWER-AMP/+120V /POWER-AMP/VASDEP 150
R4102 /POWER-AMP/+120V Net-_Q405-Pad3_ 820
Q404 /POWER-AMP/VASP Net-_C403-Pad1_ /POWER-AMP/VASDEP MJE350
C403 Net-_C403-Pad1_ /POWER-AMP/VASP 100pF
R4122 /POWER-AMP/+120V /POWER-AMP/VASDEP 820
R4101 /POWER-AMP/+120V Net-_Q405-Pad3_ 150
R4052 /POWER-AMP/+120V Net-_C403-Pad1_ 27k
R4051 /POWER-AMP/+120V Net-_C403-Pad1_ 1.5k
R409 /POWER-AMP/+120V Net-_C404-Pad1_ 1.2k
R406 Net-_R406-Pad1_ Net-_C403-Pad1_ 4.7k
RT401 /POWER-AMP/+120V Net-_R406-Pad1_ 2.5k
R4074 0 Net-_D401-Pad2_ 56k
D401 /POWER-AMP/-120V Net-_D401-Pad2_ 1N4732
R4081 Net-_Q403-Pad3_ /POWER-AMP/-120V 470
Q403 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q403-Pad3_ MJE340
.end
