.title MATRIX 1.4 IV T13 1400W RMS TD-CLASS - DEVELOPMENT RELEASE 1
.include "spice_models/model.lib"
V12 0 /POWER-AMP/-120V 120V DC
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
V32 0 /-15V 15V DC
V31 /+15V 0 15V DC
Rdummy1 VPOUT 0 4
V11 /POWER-AMP/+120V 0 120V DC
R4182 Net-_Q4132-Pad3_ VMOUT 0.15
R4192 VMOUT Net-_Q4142-Pad3_ 0.15
Q602 /POWER-AMP/+120V Net-_D603-Pad2_ Net-_Q602-Pad3_ MJE340
Q603 /POWER-AMP/+120V Net-_Q602-Pad3_ Net-_Q603-Pad3_ MJE15032
R606 Net-_Q603-Pad3_ /POWER-AMP/VSAVP 56
R605 Net-_Q602-Pad3_ /POWER-AMP/VSAVP 1.5k
Q4131 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4131-Pad3_ 2SC5200
Q4132 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4132-Pad3_ 2SC5200
R701 Net-_D701-Pad2_ /POWER-AMP/-120V 1.5k
Q701 0 Net-_D702-Pad1_ Net-_D703-Pad2_ 2N5551
D702 Net-_D702-Pad1_ VMOUT 1N4007
D703 Net-_D703-Pad1_ Net-_D703-Pad2_ 1N4734
C701 VMOUT Net-_C701-Pad2_ 10uF
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R702 Net-_C701-Pad2_ Net-_D703-Pad1_ 12k
Q4141 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4141-Pad3_ 2SA1943
Q4142 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4142-Pad3_ 2SA1943
Q412 /POWER-AMP/VSAVN /POWER-AMP/DRVN1 /POWER-AMP/DRVN2 2SA1943
R4191 VMOUT Net-_Q4141-Pad3_ 0.15
R4181 Net-_Q4131-Pad3_ VMOUT 0.15
Q411 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 /POWER-AMP/DRVP2 2SC5200
R416 VMOUT /POWER-AMP/DRVP2 5.6
R417 /POWER-AMP/DRVN2 VMOUT 5.6
R601 /POWER-AMP/+120V Net-_D601-Pad1_ 1.5k
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
R603 Net-_D602-Pad2_ 0 12k
R602 Net-_C601-Pad1_ Net-_D603-Pad2_ 12k
D602 VMOUT Net-_D602-Pad2_ 1N4007
R604 Net-_D603-Pad2_ /POWER-AMP/VSAVP 2.7k
C601 Net-_C601-Pad1_ VMOUT 10uF
D603 Net-_D603-Pad1_ Net-_D603-Pad2_ 1N4734
Q601 0 Net-_D602-Pad2_ Net-_D603-Pad1_ 2N5401
R703 0 Net-_D702-Pad1_ 12k
R704 /POWER-AMP/VSAVN Net-_D703-Pad1_ 2.7k
Q703 /POWER-AMP/-120V Net-_Q702-Pad3_ Net-_Q703-Pad3_ MJE15033
R706 /POWER-AMP/VSAVN Net-_Q703-Pad3_ 56
R705 /POWER-AMP/VSAVN Net-_Q702-Pad3_ 1.5k
Q702 /POWER-AMP/-120V Net-_D703-Pad1_ Net-_Q702-Pad3_ MJE350
D708 /POWER-AMP/-120V /POWER-AMP/VSGN 1N4742
C704 /POWER-AMP/-120V /POWER-AMP/VSAVN 1uF
L701 /POWER-AMP/VSAVN /POWER-AMP/VSFN 10uH
XQ7011 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
C703 /POWER-AMP/VSAVN Net-_C703-Pad2_ 2200pF
R713 Net-_C703-Pad2_ /POWER-AMP/VSFN 680
XQ7012 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
D709 /POWER-AMP/VSFN 0 MURF1560
R4195 VMOUT Net-_Q4145-Pad3_ 0.15
R4197 VMOUT Net-_Q4147-Pad3_ 0.15
Q4146 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4146-Pad3_ 2SA1943
R4196 VMOUT Net-_Q4146-Pad3_ 0.15
Q4148 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4148-Pad3_ 2SA1943
Q4147 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4147-Pad3_ 2SA1943
R710 Net-_Q706-Pad2_ 0 1.5k
Q704 /POWER-AMP/VSTCN Net-_Q703-Pad3_ /POWER-AMP/VSAVN 2SA1943
D705 /POWER-AMP/VSTCN Net-_D704-Pad1_ MUR810
Q705 Net-_D706-Pad2_ Net-_Q705-Pad2_ /POWER-AMP/-120V 2N5551
D706 Net-_D706-Pad1_ Net-_D706-Pad2_ BAV21
R709 Net-_D706-Pad2_ Net-_Q706-Pad2_ 1.5k
R708 /POWER-AMP/VSTCN Net-_Q705-Pad2_ 150
R707 /POWER-AMP/VSTCN /POWER-AMP/-120V 1
D704 Net-_D704-Pad1_ /POWER-AMP/-120V MUR810
C702 /POWER-AMP/-120V /POWER-AMP/VSTCN 0.01uF
R4198 VMOUT Net-_Q4148-Pad3_ 0.15
R4199 VMOUT Net-_Q4149-Pad3_ 0.15
R41910 VMOUT Net-_Q41410-Pad3_ 0.15
Q41410 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q41410-Pad3_ 2SA1943
Q4149 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4149-Pad3_ 2SA1943
Q4143 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4143-Pad3_ 2SA1943
Q4144 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4144-Pad3_ 2SA1943
Q4145 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4145-Pad3_ 2SA1943
R4194 VMOUT Net-_Q4144-Pad3_ 0.15
R4193 VMOUT Net-_Q4143-Pad3_ 0.15
D403 /POWER-AMP/VSAVN VMOUT MURF1560
C406 0 Net-_C406-Pad2_ 0.1uF
R420 VMOUT Net-_C406-Pad2_ 10
R711 Net-_D706-Pad1_ 0 15k
Q706 Net-_Q706-Pad1_ Net-_Q706-Pad2_ 0 MJE350
D707 /POWER-AMP/VSGN Net-_D707-Pad2_ BAV21
Q708 /POWER-AMP/VSGN Net-_Q707-Pad3_ /POWER-AMP/-120V 2N5551
R712 Net-_Q706-Pad1_ /POWER-AMP/VSGN 560
Q707 Net-_D707-Pad2_ Net-_D706-Pad1_ Net-_Q707-Pad3_ 2N5551
R4021 Net-_C402-Pad2_ 0 15k
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ Net-_Q401-Pad3_ MPSA42
R401 Net-_C402-Pad2_ Net-_C401-Pad2_ 180
R4022 Net-_C402-Pad2_ 0 270k
Q401 Net-_C404-Pad1_ Net-_C402-Pad2_ Net-_Q401-Pad3_ MPSA42
C401 MAIN_IN Net-_C401-Pad2_ 10uF
R4081 Net-_Q405-Pad3_ /POWER-AMP/-120V 470
R4141 Net-_Q408-Pad3_ /POWER-AMP/-120V 470
Q408 /POWER-AMP/VASN Net-_D401-Pad2_ Net-_Q408-Pad3_ MJE340
R4142 Net-_Q408-Pad3_ /POWER-AMP/-120V 47k
R4082 Net-_Q405-Pad3_ /POWER-AMP/-120V 47k
Q405 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q405-Pad3_ MJE340
D401 /POWER-AMP/-120V Net-_D401-Pad2_ 1N4732
R4072 0 Net-_D401-Pad2_ 56k
R4071 0 Net-_D401-Pad2_ 56k
R404 Net-_Q402-Pad2_ Net-_C403-Pad1_ 180
R4091 /POWER-AMP/+120V /POWER-AMP/VASDEP 150
R4052 /POWER-AMP/+120V Net-_Q403-Pad3_ 470
R4032 VMOUT Net-_Q402-Pad2_ 270k
R4031 VMOUT Net-_Q402-Pad2_ 15k
Q407 /POWER-AMP/VASN Net-_Q407-Pad2_ /POWER-AMP/VASP MJE350
R411 Net-_Q407-Pad2_ /POWER-AMP/VASP 390
R410 Net-_Q407-Pad2_ /POWER-AMP/VASN 1.2k
C405 /POWER-AMP/VASN /POWER-AMP/VASP 0.1uF
Q410 /POWER-AMP/-120V /POWER-AMP/VASN /POWER-AMP/DRVN1 MJE15033
C403 Net-_C403-Pad1_ 0 220uF
R4074 0 Net-_D401-Pad2_ 56k
R4073 0 Net-_D401-Pad2_ 56k
Q404 Net-_C404-Pad1_ Net-_Q402-Pad1_ Net-_Q404-Pad3_ MPSA92
R4062 /POWER-AMP/+120V Net-_Q404-Pad3_ 470
R4061 /POWER-AMP/+120V Net-_Q404-Pad3_ 56
C402 0 Net-_C402-Pad2_ 220pF
Q403 Net-_Q402-Pad1_ Net-_Q402-Pad1_ Net-_Q403-Pad3_ MPSA92
R4051 /POWER-AMP/+120V Net-_Q403-Pad3_ 56
RT401 /POWER-AMP/VASP Net-_R412-Pad1_ 5k
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 390
R4151 /POWER-AMP/DRVN1 /POWER-AMP/DRVP1 120
R413 /POWER-AMP/VASP Net-_R412-Pad1_ 2.2k
Q406 /POWER-AMP/VASP Net-_C404-Pad1_ /POWER-AMP/VASDEP MJE350
C404 Net-_C404-Pad1_ /POWER-AMP/VASP 220pF
R4092 /POWER-AMP/+120V /POWER-AMP/VASDEP 820
Q409 /POWER-AMP/+120V /POWER-AMP/VASP /POWER-AMP/DRVP1 MJE15032
L401 VPOUT VMOUT 1uH
D402 VMOUT /POWER-AMP/VSAVP MURF1560
R41810 Net-_Q41310-Pad3_ VMOUT 0.15
Q41310 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q41310-Pad3_ 2SC5200
R4189 Net-_Q4139-Pad3_ VMOUT 0.15
D609 0 /POWER-AMP/VSFP MURF1560
R613 /POWER-AMP/VSFP Net-_C603-Pad1_ 680
Q608 /POWER-AMP/VSGP Net-_Q607-Pad3_ /POWER-AMP/+120V 2N5401
Q607 Net-_D607-Pad1_ Net-_D606-Pad2_ Net-_Q607-Pad3_ 2N5401
R610 Net-_Q606-Pad2_ 0 1.5k
R611 Net-_D606-Pad2_ 0 15k
D606 Net-_D606-Pad1_ Net-_D606-Pad2_ BAV21
Q605 Net-_D606-Pad1_ Net-_Q605-Pad2_ /POWER-AMP/+120V 2N5401
Q606 Net-_Q606-Pad1_ Net-_Q606-Pad2_ 0 MJE340
R612 /POWER-AMP/VSGP Net-_Q606-Pad1_ 560
D607 Net-_D607-Pad1_ /POWER-AMP/VSGP BAV21
R609 Net-_D606-Pad1_ Net-_Q606-Pad2_ 1.5k
R4188 Net-_Q4138-Pad3_ VMOUT 0.15
Q4136 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4136-Pad3_ 2SC5200
Q4137 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4137-Pad3_ 2SC5200
R4187 Net-_Q4137-Pad3_ VMOUT 0.15
Q4138 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4138-Pad3_ 2SC5200
Q4139 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4139-Pad3_ 2SC5200
R4185 Net-_Q4135-Pad3_ VMOUT 0.15
R4186 Net-_Q4136-Pad3_ VMOUT 0.15
R4183 Net-_Q4133-Pad3_ VMOUT 0.15
R4184 Net-_Q4134-Pad3_ VMOUT 0.15
Q4133 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4133-Pad3_ 2SC5200
Q4134 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4134-Pad3_ 2SC5200
Q4135 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4135-Pad3_ 2SC5200
XQ6011 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
L601 /POWER-AMP/VSAVP /POWER-AMP/VSFP 10uH
C603 Net-_C603-Pad1_ /POWER-AMP/VSAVP 2200pF
XQ6012 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
D608 /POWER-AMP/VSGP /POWER-AMP/+120V 1N4742
C604 /POWER-AMP/VSAVP /POWER-AMP/+120V 1uF
R608 /POWER-AMP/VSTCP Net-_Q605-Pad2_ 150
Q604 /POWER-AMP/VSTCP Net-_Q603-Pad3_ /POWER-AMP/VSAVP 2SC5200
D604 /POWER-AMP/+120V Net-_D604-Pad2_ MUR810
D605 Net-_D604-Pad2_ /POWER-AMP/VSTCP MUR810
R607 /POWER-AMP/+120V /POWER-AMP/VSTCP 1
C602 /POWER-AMP/VSTCP /POWER-AMP/+120V 0.01uF
.end
