.title MATRIX 1.4 IV T13 1400W RMS TD-CLASS - DEVELOPMENT RELEASE 1
.include "spice_models/model.lib"
V12 0 /POWER-AMP/-120V DC 120V
V20 MAIN_IN 0 dc 0 ac 1.41 sin(0 1.41 1k 0 0)
V32 0 /-15V DC 15V
V31 /+15V 0 DC 15V
Rdummy1 VPOUT 0 4
V11 /POWER-AMP/+120V 0 DC 120V
R602 Net-_C601-Pad1_ Net-_C602-Pad1_ 22k
D604 /POWER-AMP/+120V Net-_D604-Pad2_ MURF1560
R605 /POWER-AMP/+120V /POWER-AMP/VSTCP 1
Q603 /POWER-AMP/VSTCP Net-_Q602-Pad3_ /POWER-AMP/VSAVP 2SC5200
D605 Net-_D604-Pad2_ /POWER-AMP/VSTCP MURF1560
Q602 /POWER-AMP/+120V Net-_C602-Pad1_ Net-_Q602-Pad3_ MJE15032
D603 Net-_D603-Pad1_ Net-_C602-Pad1_ 1N4734
C602 Net-_C602-Pad1_ /POWER-AMP/+120V 68pF
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
C601 Net-_C601-Pad1_ Net-_D602-Pad2_ 4.7uF
R601 /POWER-AMP/+120V Net-_D601-Pad1_ 1.2k
Q4131 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4131-Pad3_ 2SC5200
Q411 /POWER-AMP/VSAVP /POWER-AMP/DRVP1 /POWER-AMP/DRVP2 2SC5200
R604 Net-_Q602-Pad3_ /POWER-AMP/VSAVP 120
R416 VMOUT /POWER-AMP/DRVP2 5.6
Q601 0 Net-_D602-Pad2_ Net-_D603-Pad1_ 2N5401
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
R417 /POWER-AMP/DRVN2 VMOUT 5.6
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
Q412 /POWER-AMP/VSAVN /POWER-AMP/DRVN1 /POWER-AMP/DRVN2 2SA1943
Q4141 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4141-Pad3_ 2SA1943
D702 Net-_D702-Pad1_ VMOUT 1N4007
R703 0 Net-_D702-Pad1_ 22k
Q410 /POWER-AMP/-120V /POWER-AMP/VASN /POWER-AMP/DRVN1 MJE15033
C701 Net-_D702-Pad1_ Net-_C701-Pad2_ 4.7uF
C404 Net-_C404-Pad1_ /POWER-AMP/VASP 220pF
Q406 /POWER-AMP/VASP Net-_C404-Pad1_ /POWER-AMP/VASDEP MJE350
R4092 /POWER-AMP/+120V /POWER-AMP/VASDEP 820
R4151 /POWER-AMP/DRVN1 /POWER-AMP/DRVP1 120
C405 /POWER-AMP/VASN /POWER-AMP/VASP 0.1uF
R603 Net-_D602-Pad2_ 0 22k
D602 VMOUT Net-_D602-Pad2_ 1N4007
Q409 /POWER-AMP/+120V /POWER-AMP/VASP /POWER-AMP/DRVP1 MJE15032
R607 Net-_D606-Pad2_ 0 15k
Q4132 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4132-Pad3_ 2SC5200
Q4133 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4133-Pad3_ 2SC5200
XQ6011 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
L601 /POWER-AMP/VSAVP /POWER-AMP/VSFP 10uH
XQ6012 /POWER-AMP/VSFP /POWER-AMP/VSGP /POWER-AMP/+120V IRF9640
Q607 0 /POWER-AMP/VSGZP Net-_Q607-Pad3_ 2N5401
C604 /POWER-AMP/VSAVP /POWER-AMP/+120V 1uF
Q604 Net-_D606-Pad1_ Net-_Q604-Pad2_ /POWER-AMP/+120V 2N5401
D608 Net-_D606-Pad1_ Net-_D608-Pad2_ BAV21
R606 /POWER-AMP/VSTCP Net-_Q604-Pad2_ 150
Q605 /POWER-AMP/VSGZP Net-_D606-Pad2_ Net-_Q605-Pad3_ 2N5401
R608 /POWER-AMP/+120V Net-_Q605-Pad3_ 27k
D606 Net-_D606-Pad1_ Net-_D606-Pad2_ BAV21
D607 /POWER-AMP/VSGZP /POWER-AMP/+120V 1N4746
Q606 /POWER-AMP/VSGZP Net-_Q605-Pad3_ /POWER-AMP/+120V 2N5401
R612 /POWER-AMP/+120V Net-_Q608-Pad3_ 27k
R610 /POWER-AMP/VSGP Net-_Q607-Pad3_ 15
Q608 /POWER-AMP/VSGP Net-_D608-Pad2_ Net-_Q608-Pad3_ 2N5401
Q609 /POWER-AMP/VSGP Net-_Q608-Pad3_ /POWER-AMP/+120V 2N5401
R611 Net-_D608-Pad2_ 0 15k
Q4135 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4135-Pad3_ 2SC5200
Q4136 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4136-Pad3_ 2SC5200
Q4134 /POWER-AMP/VSAVP /POWER-AMP/DRVP2 Net-_Q4134-Pad3_ 2SC5200
R613 /POWER-AMP/VSFP Net-_C603-Pad2_ 680
C603 /POWER-AMP/VSAVP Net-_C603-Pad2_ 2200pF
D609 0 /POWER-AMP/VSFP MURF1560
R609 /POWER-AMP/VSGZP 0 15k
D402 VMOUT /POWER-AMP/VSAVP MURF1560
C403 Net-_C403-Pad1_ 0 220uF
R4031 VMOUT Net-_R4031-Pad2_ 15k
R404 Net-_R4031-Pad2_ Net-_C403-Pad1_ 180
R4032 VMOUT Net-_R4031-Pad2_ 270k
RT401 /POWER-AMP/VASP Net-_R412-Pad1_ 5k
R413 /POWER-AMP/VASP Net-_R412-Pad1_ 2.2k
R4091 /POWER-AMP/+120V /POWER-AMP/VASDEP 150
Q401 Net-_C404-Pad1_ Net-_Q401-Pad2_ Net-_Q401-Pad3_ MPSA42
R4051 /POWER-AMP/+120V Net-_Q403-Pad3_ 56
R4052 /POWER-AMP/+120V Net-_Q403-Pad3_ 470
Q403 Net-_Q402-Pad1_ Net-_Q402-Pad1_ Net-_Q403-Pad3_ MPSA92
Q404 Net-_C404-Pad1_ Net-_Q402-Pad1_ Net-_Q404-Pad3_ MPSA92
Q402 Net-_Q402-Pad1_ Net-_R4031-Pad2_ Net-_Q401-Pad3_ MPSA42
Q407 /POWER-AMP/VASN Net-_Q407-Pad2_ /POWER-AMP/VASP MJE350
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 390
R411 Net-_Q407-Pad2_ /POWER-AMP/VASP 390
R410 Net-_Q407-Pad2_ /POWER-AMP/VASN 1.2k
R4021 Net-_Q401-Pad2_ 0 15k
R401 Net-_Q401-Pad2_ Net-_C401-Pad2_ 180
C402 0 Net-_Q401-Pad2_ 220pF
C401 MAIN_IN Net-_C401-Pad2_ 10uF
R4022 Net-_Q401-Pad2_ 0 270k
R4071 0 Net-_D401-Pad2_ 56k
C409 /POWER-AMP/-120V 0 0.1uF
C410 0 /POWER-AMP/-120V 10uF
Q405 Net-_Q401-Pad3_ Net-_D401-Pad2_ Net-_Q405-Pad3_ MJE340
R4081 Net-_Q405-Pad3_ /POWER-AMP/-120V 470
R4061 /POWER-AMP/+120V Net-_Q404-Pad3_ 56
C407 0 /POWER-AMP/+120V 0.1uF
R4062 /POWER-AMP/+120V Net-_Q404-Pad3_ 470
C408 /POWER-AMP/+120V 0 10uF
R4082 Net-_Q405-Pad3_ /POWER-AMP/-120V 47k
D401 /POWER-AMP/-120V Net-_D401-Pad2_ 1N4732
R4141 Net-_Q408-Pad3_ /POWER-AMP/-120V 470
R4073 0 Net-_D401-Pad2_ 56k
R4072 0 Net-_D401-Pad2_ 56k
R4074 0 Net-_D401-Pad2_ 56k
R4142 Net-_Q408-Pad3_ /POWER-AMP/-120V 47k
Q408 /POWER-AMP/VASN Net-_D401-Pad2_ Net-_Q408-Pad3_ MJE340
Q4145 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4145-Pad3_ 2SA1943
Q4146 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4146-Pad3_ 2SA1943
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
Q4144 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4144-Pad3_ 2SA1943
R4193 VMOUT Net-_Q4143-Pad3_ 0.33
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
D403 /POWER-AMP/VSAVN VMOUT MURF1560
C406 0 Net-_C406-Pad2_ 0.1uF
L401 VPOUT VMOUT 1uH
R420 VMOUT Net-_C406-Pad2_ 10
Q708 /POWER-AMP/VSGN Net-_D708-Pad1_ Net-_Q708-Pad3_ 2N5551
Q709 /POWER-AMP/VSGN Net-_Q708-Pad3_ /POWER-AMP/-120V 2N5551
R711 0 Net-_D708-Pad1_ 15k
R712 Net-_Q708-Pad3_ /POWER-AMP/-120V 27k
D707 /POWER-AMP/-120V /POWER-AMP/VSGZN 1N4746
R710 Net-_Q707-Pad3_ /POWER-AMP/VSGN 15
Q707 0 /POWER-AMP/VSGZN Net-_Q707-Pad3_ 2N5551
R713 /POWER-AMP/VSFN Net-_C703-Pad2_ 680
C703 /POWER-AMP/VSAVN Net-_C703-Pad2_ 2200pF
D709 /POWER-AMP/VSFN 0 MURF1560
XQ7012 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
L701 /POWER-AMP/VSAVN /POWER-AMP/VSFN 10uH
C704 /POWER-AMP/-120V /POWER-AMP/VSAVN 1uF
XQ7011 /POWER-AMP/VSFN /POWER-AMP/VSGN /POWER-AMP/-120V IRF640
Q706 /POWER-AMP/VSGZN Net-_Q705-Pad3_ /POWER-AMP/-120V 2N5551
R709 /POWER-AMP/VSGZN 0 15k
Q705 /POWER-AMP/VSGZN Net-_D706-Pad1_ Net-_Q705-Pad3_ 2N5551
R708 /POWER-AMP/-120V Net-_Q705-Pad3_ 27k
D708 Net-_D708-Pad1_ Net-_D706-Pad2_ BAV21
R705 /POWER-AMP/VSTCN /POWER-AMP/-120V 1
R706 /POWER-AMP/VSTCN Net-_Q704-Pad2_ 150
Q703 /POWER-AMP/VSTCN Net-_Q702-Pad3_ /POWER-AMP/VSAVN 2SA1943
D706 Net-_D706-Pad1_ Net-_D706-Pad2_ BAV21
Q704 Net-_D706-Pad2_ Net-_Q704-Pad2_ /POWER-AMP/-120V 2N5551
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
Q4143 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4143-Pad3_ 2SA1943
Q4142 /POWER-AMP/VSAVN /POWER-AMP/DRVN2 Net-_Q4142-Pad3_ 2SA1943
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
R707 Net-_D706-Pad1_ 0 15k
C702 /POWER-AMP/-120V Net-_C702-Pad2_ 68pF
D704 Net-_D704-Pad1_ /POWER-AMP/-120V MURF1560
D705 /POWER-AMP/VSTCN Net-_D704-Pad1_ MURF1560
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R701 Net-_D701-Pad2_ /POWER-AMP/-120V 1.2k
Q701 0 Net-_D702-Pad1_ Net-_D703-Pad2_ 2N5551
R704 /POWER-AMP/VSAVN Net-_Q702-Pad3_ 120
D703 Net-_C702-Pad2_ Net-_D703-Pad2_ 1N4734
Q702 /POWER-AMP/-120V Net-_C702-Pad2_ Net-_Q702-Pad3_ MJE15033
R702 Net-_C701-Pad2_ Net-_C702-Pad2_ 22k
.end
